Stage-1 Rocket Engine pivot      51599    -0.76291D-03   0.92388D-02   0.44877D-03   0.31496D-06   0.26435D-04  -0.54632D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.60129D-03  -0.74732D-02  -0.11718D-03   0.28946D-04  -0.61931D-04  -0.23105D-03                                                                                                
Interstage Compartment           51980     0.96508D-03  -0.75832D-02  -0.24435D-03   0.34813D-06  -0.92216D-05   0.96592D-04                                                                                                
Spacecraft Module (aft)          52930    -0.26234D-02   0.33792D-02   0.22888D-03  -0.22163D-05   0.67561D-04  -0.11092D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.60129D-03  -0.74732D-02  -0.11718D-03                                                                                                                                          
Interstage Compartment           51980     0.96508D-03  -0.75832D-02  -0.24435D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.26234D-02   0.33792D-02   0.22888D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.27407D-02  -0.10697D-01  -0.62592D-03  -0.22811D-05   0.76645D-04  -0.12613D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.76291D-03   0.92388D-02   0.44877D-03   0.31496D-06   0.26435D-04  -0.54632D-03                                                                                                
                                                                                                                                                                                                                            
MODE #11/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.052       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.72808D-03   0.23237D-03   0.40565D-03  -0.23830D-06   0.24728D-04  -0.13894D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.53407D-03  -0.14856D-03  -0.39545D-03   0.59578D-05   0.78114D-05  -0.12811D-04                                                                                                
Interstage Compartment           51980     0.23869D-03  -0.31847D-03  -0.26690D-03   0.43862D-06  -0.73679D-05  -0.23593D-05                                                                                                
Spacecraft Module (aft)          52930    -0.15454D-02   0.22411D-03   0.35032D-04  -0.12464D-05   0.93660D-05  -0.64469D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.53407D-03  -0.14856D-03  -0.39545D-03                                                                                                                                          
Interstage Compartment           51980     0.23869D-03  -0.31847D-03  -0.26690D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.15454D-02   0.22411D-03   0.35032D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.16197D-02  -0.59751D-03  -0.84032D-04  -0.12856D-05   0.10716D-04  -0.73909D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.72808D-03   0.23237D-03   0.40565D-03  -0.23830D-06   0.24728D-04  -0.13894D-04                                                                                                
                                                                                                                                                                                                                            
MODE #12/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.346       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.14501D-02   0.31448D-03   0.10981D-02  -0.72240D-06   0.67046D-04  -0.18977D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.97089D-03  -0.18318D-03  -0.10625D-02   0.93832D-05  -0.17730D-04  -0.21439D-04                                                                                                
Interstage Compartment           51980     0.48737D-03  -0.52653D-03  -0.68034D-03   0.12254D-05  -0.21091D-04  -0.60576D-05                                                                                                
Spacecraft Module (aft)          52930    -0.28337D-02   0.39632D-03   0.93643D-04  -0.32839D-05   0.23219D-04  -0.11244D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.97089D-03  -0.18318D-03  -0.10625D-02                                                                                                                                          
Interstage Compartment           51980     0.48737D-03  -0.52653D-03  -0.68034D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.28337D-02   0.39632D-03   0.93643D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.29712D-02  -0.10375D-02  -0.20100D-03  -0.33878D-05   0.26545D-04  -0.12905D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.14501D-02   0.31448D-03   0.10981D-02  -0.72240D-06   0.67046D-04  -0.18977D-04                                                                                                
                                                                                                                                                                                                                            
MODE #13/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.665       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.13650D-02   0.15005D-03   0.16541D-02  -0.11973D-05   0.10118D-03  -0.90450D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.68821D-03  -0.71927D-04  -0.15614D-02   0.17005D-04   0.54331D-04  -0.90128D-05                                                                                                
Interstage Compartment           51980     0.43277D-03  -0.30671D-03  -0.95604D-03   0.18926D-05  -0.33862D-04  -0.54583D-05                                                                                                
Spacecraft Module (aft)          52930    -0.19924D-02   0.24540D-03   0.14197D-03  -0.47612D-05   0.32252D-04  -0.68933D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.68821D-03  -0.71927D-04  -0.15614D-02                                                                                                                                          
Interstage Compartment           51980     0.43277D-03  -0.30671D-03  -0.95604D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.19924D-02   0.24540D-03   0.14197D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.20900D-02  -0.63433D-03  -0.26627D-03  -0.49134D-05   0.36824D-04  -0.79218D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.13650D-02   0.15005D-03   0.16541D-02  -0.11973D-05   0.10118D-03  -0.90450D-05                                                                                                
                                                                                                                                                                                                                            
MODE #14/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.864       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.81633D-03  -0.20082D-03   0.16634D-01  -0.12469D-04   0.10178D-02   0.13020D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.83112D-03   0.19844D-03  -0.15403D-01   0.10774D-03   0.27137D-03   0.57892D-04                                                                                                
Interstage Compartment           51980     0.14279D-02  -0.25345D-04  -0.90616D-02   0.19498D-04  -0.35575D-03  -0.12582D-04                                                                                                
Spacecraft Module (aft)          52930    -0.10219D-02  -0.10085D-05   0.15963D-02  -0.47042D-04   0.34559D-03  -0.67409D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.83112D-03   0.19844D-03  -0.15403D-01                                                                                                                                          
Interstage Compartment           51980     0.14279D-02  -0.25345D-04  -0.90616D-02                                                                                                                                          
Spacecraft Module (aft)          52930    -0.10219D-02  -0.10085D-05   0.15963D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.10723D-02  -0.90231D-04  -0.27714D-02  -0.48556D-04   0.39427D-03  -0.79783D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.81633D-03  -0.20082D-03   0.16634D-01  -0.12469D-04   0.10178D-02   0.13020D-04                                                                                                
                                                                                                                                                                                                                            
MODE #15/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.914       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.21761D-02  -0.29767D-03   0.17993D-02  -0.12956D-05   0.10973D-03   0.17736D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.15691D-02   0.13820D-03  -0.15874D-02   0.20538D-05  -0.22666D-05   0.34114D-04                                                                                                
Interstage Compartment           51980    -0.41884D-03   0.55415D-03  -0.91152D-03   0.22122D-05  -0.40240D-04   0.79558D-05                                                                                                
Spacecraft Module (aft)          52930     0.33972D-02  -0.47284D-03   0.25765D-03  -0.51337D-05   0.56408D-04   0.12916D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.15691D-02   0.13820D-03  -0.15874D-02                                                                                                                                          
Interstage Compartment           51980    -0.41884D-03   0.55415D-03  -0.91152D-03                                                                                                                                          
Spacecraft Module (aft)          52930     0.33972D-02  -0.47284D-03   0.25765D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.35649D-02   0.11754D-02  -0.45576D-03  -0.52990D-05   0.64397D-04   0.14850D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.21761D-02  -0.29767D-03   0.17993D-02  -0.12956D-05   0.10973D-03   0.17736D-04                                                                                                
                                                                                                                                                                                                                            
MODE #16/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    70.060       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.48560D-03  -0.38203D-03   0.24484D-01  -0.19523D-04   0.15006D-02   0.24100D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.22588D-02   0.27337D-03  -0.22752D-01   0.14684D-03   0.36286D-03   0.10385D-03                                                                                                
Interstage Compartment           51980     0.17299D-02   0.28946D-03  -0.12995D-01   0.28634D-04  -0.53339D-03  -0.99742D-05                                                                                                
Spacecraft Module (aft)          52930     0.11470D-02  -0.34525D-03   0.19610D-02  -0.67564D-04   0.39643D-03   0.83597D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.22588D-02   0.27337D-03  -0.22752D-01                                                                                                                                          
Interstage Compartment           51980     0.17299D-02   0.28946D-03  -0.12995D-01                                                                                                                                          
Spacecraft Module (aft)          52930     0.11470D-02  -0.34525D-03   0.19610D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.12039D-02   0.71714D-03  -0.30363D-02  -0.69749D-04   0.45155D-03   0.95832D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.48560D-03  -0.38203D-03   0.24484D-01  -0.19523D-04   0.15006D-02   0.24100D-04                                                                                                
                                                                                                                                                                                                                            
MODE #17/ 49, Frequency (rad/sec), Damping (zeta), Generalized Mass=    70.209       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.72255D-03  -0.25666D-04   0.39433D-03  -0.32687D-06   0.23898D-04   0.80168D-06                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.36095D-04   0.28985D-05  -0.36098D-03   0.25783D-05   0.73988D-05   0.13079D-05                                                                                                
Interstage Compartment           51980     0.59702D-04   0.83628D-05  -0.21262D-03   0.46297D-06  -0.81475D-05  -0.19627D-06                                                                                                
Spacecraft Module (aft)          52930    -0.14900D-03  -0.99102D-05   0.30013D-04  -0.10860D-05   0.62472D-05   0.25488D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.36095D-04   0.28985D-05  -0.36098D-03                                                                                                                                          
Interstage Compartment           51980     0.59702D-04   0.83628D-05  -0.21262D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.14900D-03  -0.99102D-05   0.30013D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.15642D-03   0.22576D-04  -0.48889D-04  -0.11212D-05   0.71288D-05   0.29296D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.72255D-03  -0.25666D-04   0.39433D-03  -0.32687D-06   0.23898D-04   0.80168D-06                                                                                                
                                                                                                                                                                                                                            
MODE #18/ 65, Frequency (rad/sec), Damping (zeta), Generalized Mass=    75.440       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.53399D-05  -0.21956D-01  -0.35158D-03   0.91348D-06  -0.21854D-04   0.14072D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.28780D-03   0.21865D-01   0.35508D-03   0.71764D-04  -0.10628D-03   0.69614D-04                                                                                                
Interstage Compartment           51980    -0.56464D-02   0.32988D-02   0.76151D-03  -0.47804D-06  -0.15948D-04  -0.63200D-03                                                                                                
Spacecraft Module (aft)          52930    -0.44882D-03   0.93504D-02   0.13767D-02   0.11635D-05   0.25584D-03  -0.20452D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.28780D-03   0.21865D-01   0.35508D-03                                                                                                                                          
Interstage Compartment           51980    -0.56464D-02   0.32988D-02   0.76151D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.44882D-03   0.93504D-02   0.13767D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.47482D-03  -0.17036D-01  -0.18930D-02   0.12076D-05   0.29845D-03  -0.24041D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.53399D-05  -0.21956D-01  -0.35158D-03   0.91348D-06  -0.21854D-04   0.14072D-02                                                                                                
                                                                                                                                                                                                                            
MODE #19/ 67, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.893       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.61334D-03   0.31544D-03   0.10482D-03  -0.29070D-06   0.69215D-05  -0.20452D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.63951D-03  -0.28463D-03  -0.13267D-03   0.25433D-05   0.23195D-04  -0.51055D-05                                                                                                
Interstage Compartment           51980     0.46510D-03  -0.10143D-03  -0.50990D-04   0.28000D-07  -0.15066D-05   0.61790D-05                                                                                                
Spacecraft Module (aft)          52930    -0.24093D-03  -0.70890D-04  -0.20019D-03  -0.55310D-07  -0.37346D-04   0.14803D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.63951D-03  -0.28463D-03  -0.13267D-03                                                                                                                                          
Interstage Compartment           51980     0.46510D-03  -0.10143D-03  -0.50990D-04                                                                                                                                          
Spacecraft Module (aft)          52930    -0.24093D-03  -0.70890D-04  -0.20019D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.25549D-03   0.12071D-03   0.27982D-03  -0.57478D-07  -0.43940D-04   0.17516D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.61334D-03   0.31544D-03   0.10482D-03  -0.29070D-06   0.69215D-05  -0.20452D-04                                                                                                
                                                                                                                                                                                                                            
MODE #20/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.983       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.11390D-04   0.14497D-02  -0.24037D-02   0.58621D-05  -0.15697D-03  -0.94274D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.17281D-04  -0.14372D-02   0.24534D-02   0.17968D-05   0.18740D-04  -0.44809D-05                                                                                                
Interstage Compartment           51980     0.14620D-03   0.58041D-04   0.24988D-03  -0.12314D-05   0.66098D-04   0.47881D-04                                                                                                
Spacecraft Module (aft)          52930    -0.83130D-03  -0.81760D-03   0.27565D-02   0.15152D-05   0.53280D-03   0.16938D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.17281D-04  -0.14372D-02   0.24534D-02                                                                                                                                          
Interstage Compartment           51980     0.14620D-03   0.58041D-04   0.24988D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.83130D-03  -0.81760D-03   0.27565D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.88166D-03   0.13744D-02  -0.41098D-02   0.15748D-05   0.62838D-03   0.20045D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.11390D-04   0.14497D-02  -0.24037D-02   0.58621D-05  -0.15697D-03  -0.94274D-04                                                                                                
----------------------------------------------------------------------------------------------------------------------------                                                                                                
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Axis
System
Vehi_20flx.m
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Apollo-20, Stage-1, Max-Q, Open-Loop System (Vehicle, Actuator, FCS)                                                                                  
System
Open-Loop.m
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Apollo-20, Stage-1, Max-Q, Closed-Loop Simulation                                                                                                     
System
Closed-Loop.m
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
