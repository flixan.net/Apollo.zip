BATCH MODE INSTRUCTIONS ...............                                                             
Batch set for calculating the open and closed loop models                                                                                             
! This set of batch instructions calculates the Apollo launch vehicle state-space
! models for both rigid and flex structures. It extracts the pitch axis flex subsystem.
! It calculates also the pitch flight control system in state-space and combines it
! with the flex vehicle model in open-loop and closed-loop configurations. Finally, it
! converts the open and closed loop systems to Matlab function state-space format to be 
! loaded into Matlab workspace.
!
Flight Vehicle   : Apollo-20, Stage-1, Max-Q, Rigid Body                                                                                                                                                                    
System Modificat : Apollo-20, Stage-1, Max-Q, Rigid Body, Pitch Axis                                                                                                                                                        
Flight Vehicle   : Apollo-20, Stage-1, Max-Q, 20 Flex modes                                                                                                                                                                    
System Modificat : Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Axis        
Actuator Model   : Booster TVC Actuator                                                                                                                                                
Transf-Functions : Pitch Flight Control                                                                                                                                                                                     
System Connection: Apollo-20, Stage-1, Max-Q, Open-Loop System (Vehicle, Actuator, FCS)                                                                                                                                     
System Connection: Apollo-20, Stage-1, Max-Q, Closed-Loop Simulation
!
To Matlab Format : Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Axis
To Matlab Format : Apollo-20, Stage-1, Max-Q, Open-Loop System (Vehicle, Actuator, FCS)
To Matlab Format : Apollo-20, Stage-1, Max-Q, Closed-Loop Simulation
---------------------------------------------------------------------------------------------------------------------------------------------                                                                               
FLIGHT VEHICLE INPUT DATA ......                                                                    
Apollo-20, Stage-1, Max-Q, Rigid Body                                                                                                                 
Body Axes Output, Attitude=Euler Angles,Without GAFD, No Turn Coordination                                                                                                                                                  
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   40370.41     32.174       0.20896E+08                                                                                          
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   930380.0     2.162707e8   2.162651e8  -1.836e4, 1.94e3, -5.446e3                                                               
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -194.0513    -0.01        -0.01336                                                                                              
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.6          1491.0       840.0        35000.                                                                                  
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   70.000       64.400       0.0000       0.000                                                                                   
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0000       0.0000       0.0000       0.0000                                                                                  
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       53.000       0.0000       0.0000       0.0000       0.0000                                                        
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         0.0          90.0                                                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   255.73      243.2         243.2                                                                                                
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -305.00      0.0000        0.0          0.0                                                                                     
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   1.0500      0.027         0.0000       0.0000       0.0000       0.0000       0.0000                                           
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0000     -0.0637        0.0000       0.0000       0.0000       0.0000       0.0000                                           
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0091     -0.0637        0.0000       0.0000       0.0000       0.0000       0.0000                                           
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0000      0.0           0.0000       0.0000       0.0000       0.0000                                                        
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.0076      0.0506        0.0000       0.0000       0.0000       0.0000       0.0000                                           
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0000     -0.0506        0.0000       0.0000       0.0000       0.0000                                                        
                                                                                                                                                                                                                            
Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD                                                                                                                      
                                                                                                                                                                                                                            
Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  1   WITH TWD                                                                                                                    
                                                                                                                                                                                                                            
TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Single TVC       Gimbaling                                                                                                       
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  2847161.4    2847161.4                                                                                                          
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.00000      0.0000      5.0000       5.0000                                                                                    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        6383.0     -0.7                                                                                                    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -307.64       0.0         0.0                                                                                                    
                                                                                                                                                                                                                            
Number of Gyros, (Attitude and Rate)                                                     :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Accelerometers, Along Axis: (x,y,z)                                            :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Slosh Modes                                                                    :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Bending Modes                                                                  :  0                                                                                                                               
                                                                                                                                                                                                                            
---------------------------------------------------------------------------------------------------------------------------------------------                                                                               
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (TITLES OF THE NEW AND OLD SYSTEMS)                       
Apollo-20, Stage-1, Max-Q, Rigid Body, Pitch Axis                                                                                                     
Apollo-20, Stage-1, Max-Q, Rigid Body                                                                                                                                                                                       
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS                                                                                                                                                                  
Extract Inputs :   1   3                                                                                                                                                                                                    
Extract States :   3   4   7                                                                                                                                                                                                
Extract Outputs:   3   4   7  14                                                                                                                                                                                            
---------------------------------------------------------------------------------------------------------------------------------------------                                                                               
FLIGHT VEHICLE INPUT DATA ......                                                                    
Apollo-20, Stage-1, Max-Q, 20 Flex modes                                                                                                              
! This flex model uses 20 pitch modes. It has 3 pitch rate gyros and 3 Nz accelerometers                                                                                                                                    
! at three locations, (a) top of Stage-1, (b) in the compartment between 1st and 2nd                                                                                                                                        
! stages, and (c) at the spacecraft module. It also has an angle of attack sensor which                                                                                                                                     
! located in the front of the rocket and measures alpha and beta. The signal from the                                                                                                                                       
! alpha sensor is used for load relief during periods of high Q-bar                                                                                                                                                         
Body Axes Output, Attitude=Euler Angles,Without GAFD, No Turn Coordination                                                                                                                                                  
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   40370.41     32.174       0.20896E+08                                                                                          
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   930380.0     2.162707e8   2.162651e8  -1.836e4, 1.94e3, -5.446e3                                                               
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -194.0513    -0.01        -0.01336                                                                                              
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.6          1491.0       840.0        35000.                                                                                  
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   70.000       64.400       0.0000       0.000                                                                                   
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0000       0.0000       0.0000       0.0000                                                                                  
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       53.000       0.0000       0.0000       0.0000       0.0000                                                        
Wind Gust Vel wrt Vehi (Azim &Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz :   Gust         0.0          90.0                                                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   255.73      243.2         243.2                                                                                                
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -305.00      0.0000        0.0          0.0                                                                                     
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   1.0500      0.027         0.0000       0.0000       0.0000       0.0000       0.0000                                           
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0000     -0.0637        0.0000       0.0000       0.0000       0.0000       0.0000                                           
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0091     -0.0637        0.0000       0.0000       0.0000       0.0000       0.0000                                           
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0000      0.0           0.0000       0.0000       0.0000       0.0000                                                        
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.0076      0.0506        0.0000       0.0000       0.0000       0.0000       0.0000                                           
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0000     -0.0506        0.0000       0.0000       0.0000       0.0000                                                        
                                                                                                                                                                                                                            
Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD                                                                                                                      
                                                                                                                                                                                                                            
Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  1   WITH TWD                                                                                                                    
                                                                                                                                                                                                                            
TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Single TVC       Gimbaling                                                                                                       
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  2847161.4    2847161.4                                                                                                          
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.00000      0.0000      5.0000       5.0000                                                                                    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        6383.0     -0.7                                                                                                    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -307.64       0.0         0.0                                                                                                    
                                                                                                                                                                                                                            
Number of Gyros, (Attitude and Rate)                                                     :  3                                                                                                                               
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location (Top SRB) :  Pitch  Rate           -166.72        0.00000        0.00000                                                                     
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location (Aft Stg2):  Pitch  Rate           -135.25        0.00000        0.00000                                                                     
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location (Aft Stg2):  Pitch  Rate            -20.00        0.00000        0.00000                                                                     
                                                                                                                                                                                                                            
Number of Accelerometers, Along Axis: (x,y,z)                                            :  3                                                                                                                               
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor (Top SRB)     :  Z-axis Accelerat.     -166.72        0.00000        0.00000                                                                     
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor (Aft Stg2)    :  Z-axis Accelerat.     -135.25        0.00000        0.00000                                                                     
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor (Aft Stg2)    :  Z-axis Accelerat.     -20.0          0.00000        0.00000                                                                     
                                                                                                                                                                                                                            
Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  1                                                                                                                               
Vane Sensor No  1                                                                        : -20.00        0.00000        0.00000                                                                                             
                                                                                                                                                                                                                            
Number of Slosh Modes                                                                    :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Bending Modes                                                                  :  20                                                                                                                              
Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Modes, Nominal Stiffness                                                                                                                                                    
---------------------------------------------------------------------------------------------------------------------------------------------                                                                               
Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Modes, Soft Interstage                                                                                
Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Modes, Stiff Interstage                                                                               
---------------------------------------------------------------------------------------------------------------------------------------------                                                                               
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (TITLES OF THE NEW AND OLD SYSTEMS)                       
Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Axis                                                                                                  
Apollo-20, Stage-1, Max-Q, 20 Flex modes                                                                                                                                                                                    
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS                                                                                                                                                                  
Extract Inputs :   1   2   5                                                                                                                                                                                                
Extract States :   3   4   7  11  12  13  14  15  16  17  18  19  20  21  22  23  24  25  26  27  28  29  30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50                                                    
Extract Outputs:   3   4   7  12  13  14  15  16  17  18  20                                                                                                                                                                
---------------------------------------------------------------------------------------------------------------------------------------------                                                                               
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Booster TVC Actuator
! Thrust Vector Control Actuator for gimbaling the launch vehicle engine 
! in pitch and yaw
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)   1.8152
Kact   Power Valve and Actuator Gain .........(ft/s/ft-lb)   75.4
Kt     Piston Ram Stiffness ...................  (lb/ft)    0.45000E+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      5.8
Ie     Engine Inertia about Gimbal ............(ft-lb-s^2)   11000.0
Be     Engine Viscous Damping .................(ft-lb-sec)   17166.0
Kb     Engine Gimbal Bearing Spring Constant   (ft-lb/rad)  0.19166E+06
Kl     Engine Mount Structural Stiffness ......  (lb/ft)    0.60000E+07
Tc     Different. Pressure Feedbk Time Constant  (seconds)  0.1252
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)  0.40000E-06
Kfb    Position Feedback Gain ................. (rad/feet)  0.172
---------------------------------------------------------------------------------------------------------------------------------------------                                                                               
SYSTEM OF TRANSFER FUNCTIONS ...                                                                    
Pitch Flight Control                                                                                                                                  
! It feeds back pitch attitude, rate, and angle of attack through some                                                                                                                                                      
! filtering (low-pass and notch)                                                                                                                                                                                            
Continuous                                                                                                                                                                                                                  
TF. Block #  1 IMU Theta                                         Order of Numer, Denom=   0  1                                                                                                                              
Numer 0   10                                                                                                                                                                                                                
Denom 1   10                                                                                                                                                                                                                
TF. Block #  2 Pitch Rate Gyro                                   Order of Numer, Denom=   0  1                                                                                                                              
Numer 0   50                                                                                                                                                                                                                
Denom 1   50                                                                                                                                                                                                                
TF. Block #  3 Notch Filter 16.8 (rad)                           Order of Numer, Denom=   2  2                                                                                                                              
Numer 1.0    0.5040    282.24                                                                                                                                                                                               
Denom 1.0    6.4       256.0                                                                                                                                                                                                
TF. Block #  4 Low Pass                                          Order of Numer, Denom=   0  2                                                                                                                              
Numer 0.0    0.0       81.0                                                                                                                                                                                                 
Denom 1.0    10.8      81.0                                                                                                                                                                                                 
....................................................................................................                                                                                                                        
Block #, from Input #, Gain                                                                                                                                                                                                 
   1   1    1.000000        {TF:  1, IMU Theta   } from {Attitude Theta (rad)}                                                                                                                                              
   2   2    1.000000        {TF:  2, Pitch Rate G} from {Pitch Rate (q),(rad)}                                                                                                                                              
   3   3    0.400000        {TF:  3, Notch Filter} from {Alpha (rad)         }                                                                                                                                              
   3   4   -0.554600        {TF:  3, Notch Filter} from {Theta Command (rad) }                                                                                                                                              
...........................                                                                                                                                                                                                 
Outpt #, from Block #, Gain                                                                                                                                                                                                 
   1   4   0.9070000        {FCS Output          } from {TF:  4, Low Pass    }                                                                                                                                              
...........................                                                                                                                                                                                                 
Block #, from Block #, Gain                                                                                                                                                                                                 
   3   1    0.554600        {TF:  3, Notch Filter} from {TF:  1, IMU Theta   }                                                                                                                                              
   3   2    1.035300        {TF:  3, Notch Filter} from {TF:  2, Pitch Rate G}                                                                                                                                              
   4   3    1.000000        {TF:  4, Low Pass}     from {TF:  3, Notch}                                                                                                                                                     
...........................                                                                                                                                                                                                 
Definitions of Inputs  =   4                                                                                                                                                                                                
Attitude Theta (rad)                                                                                                                                                                                                        
Pitch Rate (q),  (rad/sec)                                                                                                                                                                                                  
Alpha (rad)                                                                                                                                                                                                                 
Theta Command (rad)                                                                                                                                                                                                         
                                                                                                                                                                                                                            
Definitions of Outputs =   1                                                                                                                                                                                                
FCS Output                                                                                                                                                                                                                  
----------------------------------------------------------------------------------------------------                                                                                                                        
INTERCONNECTION OF SYSTEMS .....                                                                    
Apollo-20, Stage-1, Max-Q, Open-Loop System (Vehicle, Actuator, FCS)                                                                                  
! This Interconnection set combines the actuator with the pitch vehicle system                                                                                                                                              
! and the flight control system in series fo form an open-loop system for                                                                                                                                                   
! frequency domain analysis.                                                                                                                                                                                                
Titles of Systems to be Combined                                                                                                                                                                                            
Title 1 Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Axis                                                                                                                                                                
Title 2 Booster TVC Actuator                                                                                                                                                                                                
Title 3 Pitch Flight Control                                                                                                                                                                                                
SYSTEM INPUTS TO SUBSYSTEM  2                                           Inputs to Actuator                                                                                                                                  
System Input  1 to Subsystem  2, Input  1, Gain= 1.00000                Actuator Input                                                                                                                                      
..............................................................................                                                                                                                                              
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                        FCS Output                                                                                                                                          
System Output  1 from Subsystem  3, Output  1, Gain= -1.0                                                                                                                                                                    
..............................................................................                                                                                                                                              
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                 Actuator to Vehicle                                                                                                                                 
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0            delta-y                                                                                                                                             
Subsystem  2, Output  3 to Subsystem  1, Input  2, Gain= 1.0            delta-y-ddot                                                                                                                                        
..............................................................................                                                                                                                                              
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                 Vehicle to Actuator                                                                                                                                 
Subsystem  1, Output 11 to Subsystem  2, Input  2, Gain= 1.0            Load-Torque feedback                                                                                                                                
..............................................................................                                                                                                                                              
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                 Vehicle to FCS                                                                                                                                      
Subsystem  1, Output  1 to Subsystem  3, Input  1, Gain= 1.0            Theta                                                                                                                                               
Subsystem  1, Output  4 to Subsystem  3, Input  2, Gain= 1.0            q1-flex                                                                                                                                             
Subsystem  1, Output 10 to Subsystem  3, Input  3, Gain= 1.0            alpha-sensor                                                                                                                                        
..............................................................................                                                                                                                                              
Definitions of Inputs  =   1                                                                                                                                                                                                
Gimbal deflection command to actuator                                                                                                                                                                                       
                                                                                                                                                                                                                            
Definitions of Outputs =   1                                                                                                                                                                                                
Flight Control System Output                                                                                                                                                                                                
----------------------------------------------------------------------------------------------------------------------------                                                                                                
INTERCONNECTION OF SYSTEMS .....                                                                    
Apollo-20, Stage-1, Max-Q, Closed-Loop Simulation                                                                                                     
! This Interconnection set combines the actuator with the pitch vehicle system                                                                                                                                              
! and the flight control system in closed-loop form to synthesize a simulation                                                                                                                                              
! model. The actuator receives the deflection command from the flight control                                                                                                                                               
! system and rotates the booster gimbal in the pitch direction.                                                                                                                                                             
! The system has two inputs, (a) an attitude command from guidance and (b) a                                                                                                                                                
! wind gust input. The direction of the wind gust is along the -z axis.                                                                                                                                                     
Titles of Systems to be Combined                                                                                                                                                                                            
Title 1 Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Axis                                                                                                                                                                
Title 2 Booster TVC Actuator                                                                                                                                                                                                
Title 3 Pitch Flight Control                                                                                                                                                                                                
SYSTEM INPUTS TO SUBSYSTEM  3                                           To FCS                                                                                                                                              
System Input  1 to Subsystem  3, Input  4, Gain= 1.00000                Theta Command                                                                                                                                       
..............................................................................                                                                                                                                              
SYSTEM INPUTS TO SUBSYSTEM  1                                           To Vehicle                                                                                                                                          
System Input  2 to Subsystem  1, Input  3, Gain= 1.00000                Wind Gust                                                                                                                                           
..............................................................................                                                                                                                                              
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                        Vehicle Outputs                                                                                                                                     
Via Matrix +I11                                                         all                                                                                                                                                 
..............................................................................                                                                                                                                              
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                        Actuator                                                                                                                                            
System Output 12 from Subsystem  2, Output  1, Gain= 1.0                delta-y                                                                                                                                             
System Output 13 from Subsystem  2, Output  2, Gain= 1.0                delta-y-ddot                                                                                                                                        
..............................................................................                                                                                                                                              
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                 Actuator to Vehicle                                                                                                                                 
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0            delta-y                                                                                                                                             
Subsystem  2, Output  3 to Subsystem  1, Input  2, Gain= 1.0            delta-y-ddot                                                                                                                                        
..............................................................................                                                                                                                                              
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                 Vehicle to Actuator                                                                                                                                 
Subsystem  1, Output 11 to Subsystem  2, Input  2, Gain= 1.0            Load-Torque feedback                                                                                                                                
..............................................................................                                                                                                                                              
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                 Vehicle to FCS                                                                                                                                      
Subsystem  1, Output  1 to Subsystem  3, Input  1, Gain= 1.0            Theta                                                                                                                                               
Subsystem  1, Output  4 to Subsystem  3, Input  2, Gain= 1.0            q1-flex                                                                                                                                             
Subsystem  1, Output 10 to Subsystem  3, Input  3, Gain= 1.0            alpha-sensor                                                                                                                                        
..............................................................................                                                                                                                                              
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  2                                 FCS to Actuator                                                                                                                                     
Subsystem  3, Output  1 to Subsystem  2, Input  1, Gain= 1.0            delta-y feedback                                                                                                                                    
..............................................................................                                                                                                                                              
Definitions of Inputs  =   2                                                                                                                                                                                                
Attitude command Theta (rad)                                                                                                                                                                                                
Pitch Wind Gust Velocity (ft/sec), Normal to vehicle                                                                                                                                                                        
                                                                                                                                                                                                                            
Definitions of Outputs =  13                                                                                                                                                                                                
Pitch Attitude (thet-bdy) (radians)                                                                                                                                                                                         
Pitch Rate     (q-body)   (rad/sec)                                                                                                                                                                                         
Angle of attack, alfa, (radians)                                                                                                                                                                                            
Rate-Gyro #  1, Pitch Rate (Body) (rad/sec)                                                                                                                                                                                 
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                                                                                                                                                 
Rate-Gyro #  3, Pitch Rate (Body) (rad/sec)                                                                                                                                                                                 
Accelerom #  1, (along Z), (ft/sec^2) Translat. Accelerat.                                                                                                                                                                  
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                                                                                                                                                  
Accelerom #  3, (along Z), (ft/sec^2) Translat. Accelerat.                                                                                                                                                                  
Alpha Sensed at Vane # 1 (radian)                                                                                                                                                                                           
Ptch Load-Torque Tly for Engine: 1,(ft-lb)                                                                                                                                                                                  
Gimbal deflection (rad)                                                                                                                                                                                                     
Gimbal Acceleration (rad/sec^2)                                                                                                                                                                                             
----------------------------------------------------------------------------------------------------------------------------                                                                                                
SELECTED MODAL DATA AND LOCATIONS FOR THE PITCH MODES                                               
Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Modes, Nominal Stiffness                                                                              
! The modes were selected by applying a force along the z direction at the gimbal and reading the                                                                                                                           
! pitch rotation at the stage-1 gyro and the Nz acceleration at the alpha sensor. They were                                                                                                                                 
! extracted from the nominal stiffness FEM file "Apollo_Nom.Mod" and rescaled for units/directions                                                                                                                          
                                                                                                                                                                                                                            
MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.3352       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.53881D-05   0.71903D-04  -0.26600D-01   0.88777D-05  -0.47057D-03  -0.13157D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.19430D-03   0.11644D-04   0.19410D-01   0.29117D-05   0.39856D-04  -0.17504D-04                                                                                                
2nd Stage Compartm (between ta   52320    -0.47695D-02   0.95639D-04  -0.91468D-04  -0.11318D-05   0.54564D-03   0.19661D-05                                                                                                
Spacecraft Module (aft)          52930    -0.61976D-05   0.10431D-03  -0.42950D-01   0.10998D-04   0.79624D-03   0.20088D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.19430D-03   0.11644D-04   0.19410D-01                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.47695D-02   0.95639D-04  -0.91468D-04                                                                                                                                          
Spacecraft Module (aft)          52930    -0.61976D-05   0.10431D-03  -0.42950D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.62010D-05   0.12754D-03  -0.52160D-01   0.11001D-04   0.80072D-03   0.20198D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.53881D-05   0.71903D-04  -0.26600D-01   0.88777D-05  -0.47057D-03  -0.13157D-05                                                                                                
                                                                                                                                                                                                                            
MODE # 2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.4826       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.32466D-04   0.26720D-01   0.68392D-04  -0.47443D-06   0.11687D-05  -0.47489D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.16616D-05  -0.19165D-01  -0.46462D-05  -0.60050D-05   0.12101D-04   0.33056D-04                                                                                                
2nd Stage Compartm (between ta   52320     0.13416D-03  -0.15305D-03   0.35224D-05  -0.11746D-04  -0.10799D-05   0.53017D-03                                                                                                
Spacecraft Module (aft)          52930     0.12176D-03   0.43114D-01   0.12615D-03   0.37346D-06  -0.23065D-05   0.80504D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.16616D-05  -0.19165D-01  -0.46462D-05                                                                                                                                          
2nd Stage Compartm (between ta   52320     0.13416D-03  -0.15305D-03   0.35224D-05                                                                                                                                          
Spacecraft Module (aft)          52930     0.12176D-03   0.43114D-01   0.12615D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.12183D-03   0.52428D-01   0.15284D-03   0.37360D-06  -0.23201D-05   0.80974D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.32466D-04   0.26720D-01   0.68392D-04  -0.47443D-06   0.11687D-05  -0.47489D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    16.975       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.12612D-04  -0.39464D-02  -0.24607D-01  -0.48071D-05  -0.66061D-03   0.10574D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.25719D-02   0.25439D-03   0.17576D-02   0.39025D-04   0.49577D-03  -0.83230D-04                                                                                                
2nd Stage Compartm (between ta   52320     0.11425D-02  -0.33406D-02  -0.21742D-01  -0.28176D-03  -0.18730D-03   0.19520D-04                                                                                                
Spacecraft Module (aft)          52930    -0.99731D-05   0.43137D-02   0.27576D-01   0.87245D-05  -0.11256D-02   0.17742D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.25719D-02   0.25439D-03   0.17576D-02                                                                                                                                          
2nd Stage Compartm (between ta   52320     0.11425D-02  -0.33406D-02  -0.21742D-01                                                                                                                                          
Spacecraft Module (aft)          52930    -0.99731D-05   0.43137D-02   0.27576D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.99999D-05   0.63944D-02   0.40778D-01   0.87407D-05  -0.11463D-02   0.18067D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.12612D-04  -0.39464D-02  -0.24607D-01  -0.48071D-05  -0.66061D-03   0.10574D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    17.092       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.19382D-04  -0.24932D-01   0.39360D-02   0.10645D-05   0.10616D-03   0.67114D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.92451D-03   0.13033D-02  -0.10962D-03   0.19056D-04  -0.11087D-03  -0.49010D-03                                                                                                
2nd Stage Compartm (between ta   52320    -0.21587D-03  -0.22340D-01   0.35105D-02  -0.22825D-04   0.17678D-04   0.13568D-03                                                                                                
Spacecraft Module (aft)          52930    -0.44643D-04   0.27211D-01  -0.43956D-02  -0.16189D-05   0.18179D-03   0.11312D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.92451D-03   0.13033D-02  -0.10962D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.21587D-03  -0.22340D-01   0.35105D-02                                                                                                                                          
Spacecraft Module (aft)          52930    -0.44643D-04   0.27211D-01  -0.43956D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.44770D-04   0.40479D-01  -0.65281D-02  -0.16219D-05   0.18516D-03   0.11521D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.19382D-04  -0.24932D-01   0.39360D-02   0.10645D-05   0.10616D-03   0.67114D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    33.423       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.70578D-05  -0.46671D-03   0.29274D-01   0.11920D-04   0.11387D-02   0.18662D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.69665D-03  -0.34753D-03   0.27905D-01   0.16697D-05  -0.97514D-04  -0.61840D-04                                                                                                
2nd Stage Compartm (between ta   52320    -0.45926D-02   0.68487D-03  -0.12955D-01  -0.13284D-02   0.64094D-03   0.33778D-04                                                                                                
Spacecraft Module (aft)          52930     0.10484D-04  -0.27813D-03   0.89576D-02   0.29738D-04  -0.89802D-03  -0.25331D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.69665D-03  -0.34753D-03   0.27905D-01                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.45926D-02   0.68487D-03  -0.12955D-01                                                                                                                                          
Spacecraft Module (aft)          52930     0.10484D-04  -0.27813D-03   0.89576D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.10600D-04  -0.58475D-03   0.19805D-01   0.29952D-04  -0.94304D-03  -0.26642D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.70578D-05  -0.46671D-03   0.29274D-01   0.11920D-04   0.11387D-02   0.18662D-04                                                                                                
                                                                                                                                                                                                                            
MODE # 6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    34.582       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.25613D-03  -0.31022D-01  -0.77172D-03  -0.21835D-05  -0.30030D-04   0.12305D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.27859D-03  -0.29254D-01  -0.61190D-03  -0.38305D-04   0.72122D-04  -0.68123D-04                                                                                                
2nd Stage Compartm (between ta   52320     0.82778D-03   0.15724D-01   0.25529D-03   0.55499D-04   0.14746D-04   0.48478D-03                                                                                                
Spacecraft Module (aft)          52930     0.95423D-03  -0.61851D-02   0.33572D-04   0.54522D-05   0.17527D-05  -0.83470D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.27859D-03  -0.29254D-01  -0.61190D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320     0.82778D-03   0.15724D-01   0.25529D-03                                                                                                                                          
Spacecraft Module (aft)          52930     0.95423D-03  -0.61851D-02   0.33572D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.96529D-03  -0.16246D-01   0.13710D-04   0.54943D-05   0.17564D-05  -0.87587D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.25613D-03  -0.31022D-01  -0.77172D-03  -0.21835D-05  -0.30030D-04   0.12305D-02                                                                                                
                                                                                                                                                                                                                            
MODE # 7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    40.804       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.27189D-03   0.79370D-03  -0.11975D-01   0.12397D-04  -0.52446D-03  -0.35012D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.10543D-02   0.57035D-03  -0.93713D-02  -0.42022D-04  -0.22385D-03   0.11622D-04                                                                                                
2nd Stage Compartm (between ta   52320    -0.36510D-02  -0.98781D-03   0.57027D-02  -0.30594D-02   0.10839D-02   0.98176D-04                                                                                                
Spacecraft Module (aft)          52930    -0.77560D-03  -0.29391D-03   0.71149D-02  -0.50486D-04  -0.62174D-03  -0.26009D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.10543D-02   0.57035D-03  -0.93713D-02                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.36510D-02  -0.98781D-03   0.57027D-02                                                                                                                                          
Spacecraft Module (aft)          52930    -0.77560D-03  -0.29391D-03   0.71149D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.78817D-03  -0.33640D-03   0.14851D-01  -0.51030D-04  -0.67176D-03  -0.34788D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.27189D-03   0.79370D-03  -0.11975D-01   0.12397D-04  -0.52446D-03  -0.35012D-04                                                                                                
                                                                                                                                                                                                                            
MODE # 8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    48.590       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.90984D-02  -0.14943D-02   0.51988D-03  -0.46015D-04   0.24271D-04   0.72538D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.28731D-02  -0.34539D-04  -0.61380D-04   0.27062D-04   0.40199D-04  -0.44015D-04                                                                                                
2nd Stage Compartm (between ta   52320    -0.19240D-01   0.79850D-03  -0.99032D-03   0.29106D-03   0.85088D-03   0.12344D-04                                                                                                
Spacecraft Module (aft)          52930    -0.28013D-01  -0.65346D-05  -0.20486D-03   0.11895D-03   0.14785D-04  -0.17612D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.28731D-02  -0.34539D-04  -0.61380D-04                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.19240D-01   0.79850D-03  -0.99032D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.28013D-01  -0.65346D-05  -0.20486D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.28662D-01  -0.22244D-03  -0.39720D-03   0.12078D-03   0.16667D-04  -0.18967D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.90984D-02  -0.14943D-02   0.51988D-03  -0.46015D-04   0.24271D-04   0.72538D-04                                                                                                
                                                                                                                                                                                                                            
MODE # 9/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.624       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.48160D-03   0.22621D-01   0.72981D-03   0.28721D-05   0.41174D-04  -0.12988D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.53723D-03  -0.17355D-01   0.25313D-03   0.86821D-04  -0.38975D-04  -0.83636D-03                                                                                                
2nd Stage Compartm (between ta   52320     0.56877D-03   0.14976D-01   0.10231D-02  -0.25918D-03  -0.13014D-03   0.16105D-02                                                                                                
Spacecraft Module (aft)          52930    -0.24619D-03   0.52635D-02   0.34779D-03  -0.78084D-05   0.12410D-03  -0.22124D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
