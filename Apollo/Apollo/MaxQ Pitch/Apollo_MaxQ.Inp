Stage-1 Rocket Booster gyro        195     0.53723D-03  -0.17355D-01   0.25313D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320     0.56877D-03   0.14976D-01   0.10231D-02                                                                                                                                          
Spacecraft Module (aft)          52930    -0.24619D-03   0.52635D-02   0.34779D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.25614D-03  -0.22674D-01  -0.12141D-02  -0.80154D-05   0.13939D-03  -0.24916D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.48160D-03   0.22621D-01   0.72981D-03   0.28721D-05   0.41174D-04  -0.12988D-02                                                                                                
                                                                                                                                                                                                                            
MODE #10/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    64.106       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.25966D-02   0.15964D-02   0.21718D-03   0.83881D-07   0.12901D-04  -0.91927D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.13544D-02  -0.12202D-02  -0.16275D-03   0.10882D-04   0.85774D-05  -0.72814D-04                                                                                                
2nd Stage Compartm (between ta   52320    -0.98871D-03   0.11698D-02   0.44530D-06   0.28327D-05   0.12281D-03   0.12973D-03                                                                                                
Spacecraft Module (aft)          52930    -0.22821D-02   0.44354D-03   0.27390D-04  -0.10731D-05   0.12010D-04  -0.17892D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.13544D-02  -0.12202D-02  -0.16275D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.98871D-03   0.11698D-02   0.44530D-06                                                                                                                                          
Spacecraft Module (aft)          52930    -0.22821D-02   0.44354D-03   0.27390D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.23760D-02  -0.18177D-02  -0.12463D-03  -0.11020D-05   0.13562D-04  -0.20180D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.25966D-02   0.15964D-02   0.21718D-03   0.83881D-07   0.12901D-04  -0.91927D-04                                                                                                
                                                                                                                                                                                                                            
MODE #11/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    65.435       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.15833D-02  -0.22175D-03  -0.20001D-03   0.12926D-06  -0.11979D-04   0.12787D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.10076D-02   0.16213D-03   0.18505D-03  -0.91807D-05  -0.52700D-04   0.16067D-04                                                                                                
2nd Stage Compartm (between ta   52320     0.62755D-03  -0.21516D-03   0.14011D-04  -0.11285D-04  -0.90214D-04  -0.26423D-04                                                                                                
Spacecraft Module (aft)          52930     0.14972D-02  -0.10084D-03  -0.11547D-04   0.64435D-06  -0.47867D-05   0.36775D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.10076D-02   0.16213D-03   0.18505D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320     0.62755D-03  -0.21516D-03   0.14011D-04                                                                                                                                          
Spacecraft Module (aft)          52930     0.14972D-02  -0.10084D-03  -0.11547D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.15615D-02   0.36501D-03   0.49259D-04   0.66246D-06  -0.54341D-05   0.41656D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.15833D-02  -0.22175D-03  -0.20001D-03   0.12926D-06  -0.11979D-04   0.12787D-04                                                                                                
                                                                                                                                                                                                                            
MODE #12/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    66.610       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.14147D-02   0.96220D-04   0.57071D-03  -0.46367D-06   0.34099D-04  -0.54570D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.10848D-02  -0.48987D-04  -0.54839D-03   0.24470D-05  -0.25604D-04  -0.15870D-04                                                                                                
2nd Stage Compartm (between ta   52320    -0.58942D-03   0.17961D-03   0.10153D-03   0.92808D-05   0.98875D-04   0.24864D-04                                                                                                
Spacecraft Module (aft)          52930    -0.16246D-02   0.10316D-03   0.41078D-04  -0.16937D-05   0.11593D-04  -0.34909D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.10848D-02  -0.48987D-04  -0.54839D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.58942D-03   0.17961D-03   0.10153D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.16246D-02   0.10316D-03   0.41078D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.16970D-02  -0.34004D-03  -0.10534D-03  -0.17430D-05   0.13130D-04  -0.39701D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.14147D-02   0.96220D-04   0.57071D-03  -0.46367D-06   0.34099D-04  -0.54570D-05                                                                                                
                                                                                                                                                                                                                            
MODE #13/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.327       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.76628D-04   0.54737D-03  -0.26287D-01   0.23401D-04  -0.15703D-02  -0.33522D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.39793D-02  -0.50781D-03   0.24064D-01  -0.17400D-03  -0.76626D-03  -0.93284D-04                                                                                                
2nd Stage Compartm (between ta   52320    -0.44137D-02   0.77271D-03  -0.91453D-02   0.28231D-03   0.36409D-03   0.18036D-04                                                                                                
Spacecraft Module (aft)          52930     0.49023D-03   0.20836D-03  -0.21918D-02   0.74731D-04  -0.50297D-03  -0.51288D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.39793D-02  -0.50781D-03   0.24064D-01                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.44137D-02   0.77271D-03  -0.91453D-02                                                                                                                                          
Spacecraft Module (aft)          52930     0.49023D-03   0.20836D-03  -0.21918D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.51258D-03  -0.43790D-03   0.41290D-02   0.76958D-04  -0.56825D-03  -0.58067D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.76628D-04   0.54737D-03  -0.26287D-01   0.23401D-04  -0.15703D-02  -0.33522D-04                                                                                                
                                                                                                                                                                                                                            
MODE #14/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.352       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.43784D-05  -0.32128D-03   0.13782D-01  -0.12331D-04   0.82354D-03   0.19615D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.21477D-02   0.30000D-03  -0.12628D-01   0.91178D-04   0.39964D-03   0.49531D-04                                                                                                
2nd Stage Compartm (between ta   52320     0.30498D-02  -0.38629D-03   0.49193D-02  -0.16973D-03  -0.29212D-03  -0.86453D-05                                                                                                
Spacecraft Module (aft)          52930     0.14962D-02  -0.10227D-03   0.11643D-02  -0.39094D-04   0.26543D-03   0.24757D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.21477D-02   0.30000D-03  -0.12628D-01                                                                                                                                          
2nd Stage Compartm (between ta   52320     0.30498D-02  -0.38629D-03   0.49193D-02                                                                                                                                          
Spacecraft Module (aft)          52930     0.14962D-02  -0.10227D-03   0.11643D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.15645D-02   0.20951D-03  -0.21706D-02  -0.40260D-04   0.29984D-03   0.28019D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.43784D-05  -0.32128D-03   0.13782D-01  -0.12331D-04   0.82354D-03   0.19615D-04                                                                                                
                                                                                                                                                                                                                            
MODE #15/ 38, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.560       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.32763D-04   0.41422D-04  -0.49923D-03   0.46531D-06  -0.29738D-04  -0.18966D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.29816D-03  -0.16521D-04   0.45497D-03  -0.22494D-05  -0.10539D-04  -0.51082D-05                                                                                                
2nd Stage Compartm (between ta   52320    -0.19663D-03   0.63041D-04  -0.18889D-03   0.72913D-05   0.25805D-04   0.69490D-05                                                                                                
Spacecraft Module (aft)          52930    -0.26899D-03   0.34360D-04  -0.42143D-04   0.14071D-05  -0.92537D-05  -0.10576D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.29816D-03  -0.16521D-04   0.45497D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.19663D-03   0.63041D-04  -0.18889D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.26899D-03   0.34360D-04  -0.42143D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.28134D-03  -0.99997D-04   0.74021D-04   0.14494D-05  -0.10451D-04  -0.12056D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.32763D-04   0.41422D-04  -0.49923D-03   0.46531D-06  -0.29738D-04  -0.18966D-05                                                                                                
                                                                                                                                                                                                                            
MODE #16/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.598       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.16994D-02   0.36521D-04   0.16953D-03  -0.15355D-06   0.10082D-04  -0.23473D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.13497D-02  -0.61415D-04  -0.14197D-03  -0.68179D-05  -0.52807D-04   0.99677D-05                                                                                                
2nd Stage Compartm (between ta   52320     0.53118D-03  -0.10306D-03   0.12763D-03  -0.95940D-05  -0.10225D-03  -0.16145D-04                                                                                                
Spacecraft Module (aft)          52930     0.13325D-02  -0.85978D-04   0.22925D-04  -0.47279D-06   0.35825D-05   0.24175D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.13497D-02  -0.61415D-04  -0.14197D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320     0.53118D-03  -0.10306D-03   0.12763D-03                                                                                                                                          
Spacecraft Module (aft)          52930     0.13325D-02  -0.85978D-04   0.22925D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.13976D-02   0.22249D-03  -0.21520D-04  -0.48787D-06   0.40254D-05   0.27774D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.16994D-02   0.36521D-04   0.16953D-03  -0.15355D-06   0.10082D-04  -0.23473D-05                                                                                                
                                                                                                                                                                                                                            
MODE #17/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.793       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.14087D-02   0.49182D-04   0.15188D-03  -0.14207D-06   0.89899D-05  -0.33942D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.12652D-02  -0.82577D-04  -0.12154D-03  -0.44879D-05  -0.28152D-04   0.10039D-04                                                                                                
2nd Stage Compartm (between ta   52320     0.48890D-03  -0.11229D-03   0.67290D-04   0.40834D-05  -0.87845D-04  -0.17816D-04                                                                                                
Spacecraft Module (aft)          52930     0.12444D-02  -0.95978D-04   0.20724D-04  -0.42431D-06   0.32089D-05   0.26740D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.12652D-02  -0.82577D-04  -0.12154D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320     0.48890D-03  -0.11229D-03   0.67290D-04                                                                                                                                          
Spacecraft Module (aft)          52930     0.12444D-02  -0.95978D-04   0.20724D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.13056D-02   0.24533D-03  -0.19086D-04  -0.43793D-06   0.36071D-05   0.30742D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.14087D-02   0.49182D-04   0.15188D-03  -0.14207D-06   0.89899D-05  -0.33942D-05                                                                                                
                                                                                                                                                                                                                            
MODE #18/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.931       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.16075D-04  -0.42503D-04  -0.11399D-02   0.16460D-05  -0.69798D-04   0.25550D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.14688D-03   0.40538D-04   0.11332D-02  -0.49235D-05  -0.24460D-04  -0.29170D-05                                                                                                
2nd Stage Compartm (between ta   52320    -0.37910D-03  -0.17289D-03  -0.14523D-01   0.35510D-02   0.24902D-02  -0.24334D-04                                                                                                
Spacecraft Module (aft)          52930    -0.49993D-04   0.18610D-04   0.16851D-03   0.24193D-05   0.51145D-04  -0.44570D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.14688D-03   0.40538D-04   0.11332D-02                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.37910D-03  -0.17289D-03  -0.14523D-01                                                                                                                                          
Spacecraft Module (aft)          52930    -0.49993D-04   0.18610D-04   0.16851D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.52463D-04  -0.37983D-04  -0.48654D-03   0.24972D-05   0.58978D-04  -0.51044D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.16075D-04  -0.42503D-04  -0.11399D-02   0.16460D-05  -0.69798D-04   0.25550D-05                                                                                                
                                                                                                                                                                                                                            
MODE #19/ 62, Frequency (rad/sec), Damping (zeta), Generalized Mass=    73.632       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.51716D-05   0.20623D-01   0.44029D-03   0.22856D-05   0.27155D-04  -0.13009D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.52157D-03  -0.21532D-01  -0.32313D-03  -0.49078D-04   0.11250D-03  -0.27413D-03                                                                                                
2nd Stage Compartm (between ta   52320    -0.10774D-02  -0.56135D-02  -0.26499D-02   0.95124D-03   0.42559D-03  -0.13108D-02                                                                                                
Spacecraft Module (aft)          52930     0.29145D-03  -0.94699D-02  -0.11871D-02  -0.47669D-05  -0.23288D-03   0.22247D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.52157D-03  -0.21532D-01  -0.32313D-03                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.10774D-02  -0.56135D-02  -0.26499D-02                                                                                                                                          
Spacecraft Module (aft)          52930     0.29145D-03  -0.94699D-02  -0.11871D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.30748D-03   0.19135D-01   0.17795D-02  -0.49378D-05  -0.26971D-03   0.25958D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.51716D-05   0.20623D-01   0.44029D-03   0.22856D-05   0.27155D-04  -0.13009D-02                                                                                                
                                                                                                                                                                                                                            
MODE #20/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.934       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.15255D-04  -0.67189D-03   0.22658D-02  -0.62899D-05   0.14788D-03   0.43722D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.32240D-04   0.70400D-03  -0.23583D-02  -0.69311D-05  -0.11611D-04   0.84469D-05                                                                                                
2nd Stage Compartm (between ta   52320    -0.35872D-02   0.13795D-03  -0.28249D-01   0.30684D-02   0.39480D-02   0.87835D-04                                                                                                
Spacecraft Module (aft)          52930     0.92833D-03   0.49245D-03  -0.31142D-02  -0.97361D-06  -0.59628D-03  -0.10197D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.32240D-04   0.70400D-03  -0.23583D-02                                                                                                                                          
2nd Stage Compartm (between ta   52320    -0.35872D-02   0.13795D-03  -0.28249D-01                                                                                                                                          
Spacecraft Module (aft)          52930     0.92833D-03   0.49245D-03  -0.31142D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.98449D-03  -0.82694D-03   0.45639D-02  -0.10118D-05  -0.70268D-03  -0.12064D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.15255D-04  -0.67189D-03   0.22658D-02  -0.62899D-05   0.14788D-03   0.43722D-04                                                                                                
------------------------------------------------------------------------------------------------------------------------                                                                                                    
SELECTED MODAL DATA AND LOCATIONS FOR THE PITCH MODES                                               
Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Modes, Soft Interstage                                                                                
! The modes were selected by applying a force along the z direction at the gimbal and reading the                                                                                                                           
! pitch rotation at the stage-1 gyro and the Nz acceleration at the alpha sensor. They were                                                                                                                                 
! extracted from the reduced stiffness FEM file "Apollo_Soft.Mod" and rescaled for units/directions                                                                                                                         
                                                                                                                                                                                                                            
MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.6993       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.50966D-05   0.21672D-04  -0.25600D-01   0.96832D-05  -0.44249D-03  -0.41072D-06                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.14404D-03   0.47921D-04   0.20214D-01   0.48865D-05  -0.23018D-04  -0.14750D-04                                                                                                
Interstage Compartment           51980    -0.12850D-02   0.16699D-03   0.14320D-01  -0.40636D-04   0.39772D-03  -0.61192D-04                                                                                                
Spacecraft Module (aft)          52930    -0.60781D-05   0.27928D-04  -0.43512D-01   0.11895D-04   0.79783D-03   0.58667D-06                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.14404D-03   0.47921D-04   0.20214D-01                                                                                                                                          
Interstage Compartment           51980    -0.12850D-02   0.16699D-03   0.14320D-01                                                                                                                                          
Spacecraft Module (aft)          52930    -0.60781D-05   0.27928D-04  -0.43512D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.60809D-05   0.34702D-04  -0.52730D-01   0.11898D-04   0.80161D-03   0.58918D-06                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.50966D-05   0.21672D-04  -0.25600D-01   0.96832D-05  -0.44249D-03  -0.41072D-06                                                                                                
                                                                                                                                                                                                                            
MODE # 2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.8120       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.26254D-04   0.25663D-01   0.18558D-04  -0.63196D-06   0.28079D-06  -0.44501D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.60654D-04  -0.20037D-01   0.28778D-04  -0.53915D-05   0.10296D-04  -0.30685D-04                                                                                                
Interstage Compartment           51980     0.31022D-02  -0.14063D-01   0.11893D-03   0.31806D-04  -0.27372D-04   0.43261D-03                                                                                                
Spacecraft Module (aft)          52930     0.10084D-03   0.43674D-01   0.46404D-04   0.11694D-05  -0.81475D-06   0.80525D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.60654D-04  -0.20037D-01   0.28778D-04                                                                                                                                          
Interstage Compartment           51980     0.31022D-02  -0.14063D-01   0.11893D-03                                                                                                                                          
Spacecraft Module (aft)          52930     0.10084D-03   0.43674D-01   0.46404D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.10089D-03   0.52980D-01   0.55822D-04   0.11698D-05  -0.81888D-06   0.80918D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.26254D-04   0.25663D-01   0.18558D-04  -0.63196D-06   0.28079D-06  -0.44501D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    16.548       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.12104D-04   0.38339D-02   0.25076D-01   0.43372D-05   0.66340D-03  -0.10122D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.26256D-02  -0.35911D-03  -0.24936D-02  -0.36818D-04  -0.50502D-03   0.83021D-04                                                                                                
Interstage Compartment           51980     0.18747D-02   0.20218D-02   0.15528D-01   0.56168D-04  -0.44219D-03   0.43942D-04                                                                                                
Spacecraft Module (aft)          52930     0.11702D-04  -0.39312D-02  -0.26422D-01  -0.94546D-05   0.10769D-02  -0.16144D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.26256D-02  -0.35911D-03  -0.24936D-02                                                                                                                                          
Interstage Compartment           51980     0.18747D-02   0.20218D-02   0.15528D-01                                                                                                                                          
Spacecraft Module (aft)          52930     0.11702D-04  -0.39312D-02  -0.26422D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.11732D-04  -0.58226D-02  -0.39040D-01  -0.94711D-05   0.10957D-02  -0.16424D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.12104D-04   0.38339D-02   0.25076D-01   0.43372D-05   0.66340D-03  -0.10122D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    16.663       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.24334D-04  -0.25430D-01   0.38237D-02   0.11585D-05   0.10163D-03   0.67452D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.91884D-03   0.20503D-02  -0.22159D-03   0.19486D-04  -0.10896D-03  -0.49814D-03                                                                                                
Interstage Compartment           51980    -0.31517D-02  -0.15872D-01   0.25652D-02  -0.17440D-04  -0.92332D-04  -0.39272D-03                                                                                                
Spacecraft Module (aft)          52930    -0.65606D-04   0.26032D-01  -0.40108D-02  -0.24329D-05   0.16570D-03   0.10808D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.91884D-03   0.20503D-02  -0.22159D-03                                                                                                                                          
Interstage Compartment           51980    -0.31517D-02  -0.15872D-01   0.25652D-02                                                                                                                                          
Spacecraft Module (aft)          52930    -0.65606D-04   0.26032D-01  -0.40108D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.65783D-04   0.38697D-01  -0.59525D-02  -0.24372D-05   0.16861D-03   0.10998D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.24334D-04  -0.25430D-01   0.38237D-02   0.11585D-05   0.10163D-03   0.67452D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    32.507       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.26387D-05   0.36939D-03  -0.29526D-01  -0.12701D-04  -0.11284D-02  -0.14609D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.14432D-02   0.27995D-03  -0.29252D-01  -0.43030D-05   0.23791D-03   0.54871D-04                                                                                                
Interstage Compartment           51980     0.26794D-02  -0.86299D-03  -0.13516D-01   0.21420D-03  -0.98414D-03   0.16103D-03                                                                                                
Spacecraft Module (aft)          52930    -0.24702D-04   0.25466D-03  -0.93262D-02  -0.34991D-04   0.88876D-03   0.22138D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.14432D-02   0.27995D-03  -0.29252D-01                                                                                                                                          
Interstage Compartment           51980     0.26794D-02  -0.86299D-03  -0.13516D-01                                                                                                                                          
Spacecraft Module (aft)          52930    -0.24702D-04   0.25466D-03  -0.93262D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.24956D-04   0.52215D-03  -0.20043D-01  -0.35230D-04   0.93150D-03   0.23237D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.26387D-05   0.36939D-03  -0.29526D-01  -0.12701D-04  -0.11284D-02  -0.14609D-04                                                                                                
                                                                                                                                                                                                                            
MODE # 6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    33.419       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.25107D-03   0.30766D-01   0.61995D-03   0.44023D-05   0.23521D-04  -0.11945D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.38700D-03   0.30450D-01   0.47887D-03   0.34271D-04  -0.65396D-04   0.23078D-03                                                                                                
Interstage Compartment           51980    -0.80066D-02   0.11084D-01   0.79520D-04  -0.17284D-03   0.64933D-04  -0.11252D-02                                                                                                
Spacecraft Module (aft)          52930    -0.97538D-03   0.69140D-02  -0.36722D-04  -0.13708D-04   0.65104D-08   0.83788D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.38700D-03   0.30450D-01   0.47887D-03                                                                                                                                          
Interstage Compartment           51980    -0.80066D-02   0.11084D-01   0.79520D-04                                                                                                                                          
Spacecraft Module (aft)          52930    -0.97538D-03   0.69140D-02  -0.36722D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.98593D-03   0.16998D-01  -0.37727D-04  -0.13806D-04   0.67387D-07   0.87749D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.25107D-03   0.30766D-01   0.61995D-03   0.44023D-05   0.23521D-04  -0.11945D-02                                                                                                
                                                                                                                                                                                                                            
MODE # 7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    40.428       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.56784D-03   0.63377D-03  -0.10815D-01   0.15683D-04  -0.47099D-03  -0.27824D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.88426D-03   0.48575D-03  -0.87435D-02  -0.35861D-04  -0.18392D-03   0.92618D-05                                                                                                
Interstage Compartment           51980     0.11311D-03  -0.12388D-02   0.57011D-02   0.28187D-03  -0.41820D-03  -0.28670D-04                                                                                                
Spacecraft Module (aft)          52930    -0.18654D-02  -0.33476D-03   0.77121D-02  -0.63095D-04  -0.70566D-03  -0.10527D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.88426D-03   0.48575D-03  -0.87435D-02                                                                                                                                          
Interstage Compartment           51980     0.11311D-03  -0.12388D-02   0.57011D-02                                                                                                                                          
Spacecraft Module (aft)          52930    -0.18654D-02  -0.33476D-03   0.77121D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.18951D-02  -0.47360D-03   0.16465D-01  -0.63762D-04  -0.76040D-03  -0.11888D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.56784D-03   0.63377D-03  -0.10815D-01   0.15683D-04  -0.47099D-03  -0.27824D-04                                                                                                
                                                                                                                                                                                                                            
MODE # 8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    43.593       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.83410D-02  -0.12340D-02   0.86798D-03  -0.21008D-05   0.38700D-04   0.56126D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.75364D-03  -0.54760D-03   0.39488D-03   0.20332D-04   0.42196D-04  -0.57913D-04                                                                                                
Interstage Compartment           51980    -0.12150D-01  -0.18705D-02  -0.14868D-02  -0.12371D-03   0.19439D-03  -0.38106D-03                                                                                                
Spacecraft Module (aft)          52930    -0.28756D-01  -0.72481D-04  -0.50290D-03   0.66430D-05   0.45674D-04  -0.29608D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.75364D-03  -0.54760D-03   0.39488D-03                                                                                                                                          
Interstage Compartment           51980    -0.12150D-01  -0.18705D-02  -0.14868D-02                                                                                                                                          
Spacecraft Module (aft)          52930    -0.28756D-01  -0.72481D-04  -0.50290D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.29290D-01  -0.43338D-03  -0.10769D-02   0.67248D-05   0.49861D-04  -0.31579D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.83410D-02  -0.12340D-02   0.86798D-03  -0.21008D-05   0.38700D-04   0.56126D-04                                                                                                
                                                                                                                                                                                                                            
MODE # 9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    46.178       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.19120D-05  -0.97038D-04   0.34382D-04   0.28006D-02   0.16826D-05   0.43958D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.60477D-04  -0.15796D-02   0.79741D-03   0.18596D-04  -0.10344D-04   0.40117D-04                                                                                                
Interstage Compartment           51980    -0.24721D-04  -0.95008D-02   0.19647D-01  -0.22333D-02  -0.24062D-03   0.16634D-04                                                                                                
Spacecraft Module (aft)          52930    -0.96055D-05  -0.10346D-05  -0.26876D-04  -0.78500D-02  -0.30472D-05  -0.17754D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.60477D-04  -0.15796D-02   0.79741D-03                                                                                                                                          
Interstage Compartment           51980    -0.24721D-04  -0.95008D-02   0.19647D-01                                                                                                                                          
Spacecraft Module (aft)          52930    -0.96055D-05  -0.10346D-05  -0.26876D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.98061D-05  -0.22674D-04   0.88357D-05  -0.79585D-02  -0.31638D-05  -0.18985D-05                                                                                                
                                                                                                                                                                                                                            
