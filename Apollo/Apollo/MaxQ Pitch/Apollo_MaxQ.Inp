                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.19120D-05  -0.97038D-04   0.34382D-04   0.28006D-02   0.16826D-05   0.43958D-05                                                                                                
                                                                                                                                                                                                                            
MODE #10/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    62.039       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.13733D-03   0.23135D-01   0.75268D-03   0.38297D-05   0.41863D-04  -0.13078D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.86858D-03  -0.16927D-01   0.22580D-03   0.88138D-04  -0.42632D-04  -0.10050D-02                                                                                                
Interstage Compartment           51980     0.52254D-02  -0.24944D-01  -0.63272D-04   0.71482D-04  -0.15158D-03   0.93059D-03                                                                                                
Spacecraft Module (aft)          52930    -0.23266D-03   0.44264D-02   0.29934D-03  -0.97807D-05   0.12283D-03  -0.22210D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.86858D-03  -0.16927D-01   0.22580D-03                                                                                                                                          
Interstage Compartment           51980     0.52254D-02  -0.24944D-01  -0.63272D-04                                                                                                                                          
Spacecraft Module (aft)          52930    -0.23266D-03   0.44264D-02   0.29934D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.24157D-03  -0.23554D-01  -0.12430D-02  -0.10027D-04   0.13734D-03  -0.24898D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.13733D-03   0.23135D-01   0.75268D-03   0.38297D-05   0.41863D-04  -0.13078D-02                                                                                                
                                                                                                                                                                                                                            
MODE #11/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    64.033       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.30648D-02  -0.12635D-03  -0.23135D-03   0.25931D-06  -0.13854D-04   0.70321D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.18011D-02   0.77336D-04   0.22800D-03  -0.46087D-05  -0.17196D-04   0.17273D-04                                                                                                
Interstage Compartment           51980    -0.46719D-03   0.45876D-03   0.31892D-03   0.89594D-05  -0.10779D-04   0.42544D-04                                                                                                
Spacecraft Module (aft)          52930     0.15894D-02  -0.65966D-04  -0.11454D-04   0.57212D-06  -0.51520D-05   0.27445D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.18011D-02   0.77336D-04   0.22800D-03                                                                                                                                          
Interstage Compartment           51980    -0.46719D-03   0.45876D-03   0.31892D-03                                                                                                                                          
Spacecraft Module (aft)          52930     0.15894D-02  -0.65966D-04  -0.11454D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.16546D-02   0.28100D-03   0.53774D-04   0.58751D-06  -0.58182D-05   0.30958D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.30648D-02  -0.12635D-03  -0.23135D-03   0.25931D-06  -0.13854D-04   0.70321D-05                                                                                                
                                                                                                                                                                                                                            
MODE #12/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    65.404       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.18269D-02  -0.19048D-04  -0.62005D-03   0.71509D-06  -0.36658D-04   0.90726D-06                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.12300D-02  -0.52028D-06   0.56547D-03  -0.10380D-04  -0.70036D-04   0.64597D-05                                                                                                
Interstage Compartment           51980    -0.40099D-03   0.26308D-03   0.57763D-03  -0.28435D-05   0.99552D-05   0.27625D-04                                                                                                
Spacecraft Module (aft)          52930     0.10366D-02  -0.31030D-04  -0.41920D-04   0.14780D-05  -0.11664D-04   0.11932D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.12300D-02  -0.52028D-06   0.56547D-03                                                                                                                                          
Interstage Compartment           51980    -0.40099D-03   0.26308D-03   0.57763D-03                                                                                                                                          
Spacecraft Module (aft)          52930     0.10366D-02  -0.31030D-04  -0.41920D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.10811D-02   0.12028D-03   0.10475D-03   0.15194D-05  -0.13135D-04   0.13526D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.18269D-02  -0.19048D-04  -0.62005D-03   0.71509D-06  -0.36658D-04   0.90726D-06                                                                                                
                                                                                                                                                                                                                            
MODE #13/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    65.859       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.28289D-04   0.72263D-03  -0.29908D-01   0.33782D-04  -0.17618D-02  -0.43472D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.58173D-02  -0.70998D-03   0.27011D-01  -0.20216D-03  -0.10980D-02  -0.89551D-04                                                                                                
Interstage Compartment           51980    -0.28915D-02   0.12324D-02   0.23185D-01  -0.58462D-03   0.11765D-02  -0.32576D-03                                                                                                
Spacecraft Module (aft)          52930    -0.18620D-03   0.18617D-03  -0.22673D-02   0.72433D-04  -0.55460D-03  -0.46943D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.58173D-02  -0.70998D-03   0.27011D-01                                                                                                                                          
Interstage Compartment           51980    -0.28915D-02   0.12324D-02   0.23185D-01                                                                                                                                          
Spacecraft Module (aft)          52930    -0.18620D-03   0.18617D-03  -0.22673D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.19430D-03  -0.40309D-03   0.46871D-02   0.74496D-04  -0.62372D-03  -0.52837D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.28289D-04   0.72263D-03  -0.29908D-01   0.33782D-04  -0.17618D-02  -0.43472D-04                                                                                                
                                                                                                                                                                                                                            
MODE #14/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    66.566       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.18169D-02   0.12732D-04   0.46740D-03  -0.50894D-06   0.27426D-04  -0.93223D-06                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.17012D-02  -0.35132D-04  -0.39440D-03   0.60415D-05   0.59978D-04   0.13580D-04                                                                                                
Interstage Compartment           51980    -0.40571D-03   0.25828D-03  -0.24679D-03   0.21386D-04  -0.37346D-04   0.52471D-04                                                                                                
Spacecraft Module (aft)          52930     0.12097D-02  -0.57300D-04   0.40995D-04  -0.11567D-05   0.83909D-05   0.19242D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.17012D-02  -0.35132D-04  -0.39440D-03                                                                                                                                          
Interstage Compartment           51980    -0.40571D-03   0.25828D-03  -0.24679D-03                                                                                                                                          
Spacecraft Module (aft)          52930     0.12097D-02  -0.57300D-04   0.40995D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.12635D-02   0.18691D-03  -0.63706D-04  -0.11904D-05   0.94130D-05   0.21876D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.18169D-02   0.12732D-04   0.46740D-03  -0.50894D-06   0.27426D-04  -0.93223D-06                                                                                                
                                                                                                                                                                                                                            
MODE #15/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.150       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.14809D-04   0.38647D-04  -0.21638D-03   0.29868D-06  -0.12905D-04  -0.23033D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.63311D-04  -0.38378D-04   0.20500D-03  -0.13606D-05  -0.65876D-05  -0.16249D-05                                                                                                
Interstage Compartment           51980     0.42839D-04  -0.12029D-04   0.11788D-03   0.11970D-04   0.42974D-03  -0.10145D-02                                                                                                
Spacecraft Module (aft)          52930    -0.16738D-02  -0.50990D-05  -0.28497D-04   0.45542D-06  -0.51617D-05   0.16546D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.63311D-04  -0.38378D-04   0.20500D-03                                                                                                                                          
Interstage Compartment           51980     0.42839D-04  -0.12029D-04   0.11788D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.16738D-02  -0.50990D-05  -0.28497D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.17497D-02   0.15923D-04   0.35648D-04   0.46892D-06  -0.57785D-05   0.18850D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.14809D-04   0.38647D-04  -0.21638D-03   0.29868D-06  -0.12905D-04  -0.23033D-05                                                                                                
                                                                                                                                                                                                                            
MODE #16/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    68.823       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.32780D-02   0.15887D-03   0.21357D-03  -0.15978D-06   0.12414D-04  -0.99311D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.33723D-02  -0.20011D-03  -0.15817D-03  -0.33626D-05  -0.13222D-04   0.16825D-04                                                                                                
Interstage Compartment           51980    -0.98007D-03   0.44434D-03   0.57659D-04   0.28818D-04  -0.39256D-04   0.84829D-04                                                                                                
Spacecraft Module (aft)          52930     0.20720D-02  -0.12731D-03   0.25919D-04  -0.63125D-06   0.35518D-05   0.37709D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.33723D-02  -0.20011D-03  -0.15817D-03                                                                                                                                          
Interstage Compartment           51980    -0.98007D-03   0.44434D-03   0.57659D-04                                                                                                                                          
Spacecraft Module (aft)          52930     0.20720D-02  -0.12731D-03   0.25919D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.21710D-02   0.35333D-03  -0.17669D-04  -0.65094D-06   0.39505D-05   0.43214D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.32780D-02   0.15887D-03   0.21357D-03  -0.15978D-06   0.12414D-04  -0.99311D-05                                                                                                
                                                                                                                                                                                                                            
MODE #17/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.929       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.56255D-05  -0.96319D-04  -0.75997D-03   0.14090D-05  -0.46537D-04   0.58498D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.10535D-03   0.96469D-04   0.78005D-03  -0.27409D-05  -0.18877D-04   0.46042D-06                                                                                                
Interstage Compartment           51980    -0.86878D-04   0.11706D-03   0.24198D-03  -0.49559D-04   0.32909D-04  -0.13972D-04                                                                                                
Spacecraft Module (aft)          52930    -0.32852D-04   0.31630D-04   0.23618D-03   0.12060D-05   0.65621D-04  -0.84053D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.10535D-03   0.96469D-04   0.78005D-03                                                                                                                                          
Interstage Compartment           51980    -0.86878D-04   0.11706D-03   0.24198D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.32852D-04   0.31630D-04   0.23618D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.34475D-04  -0.75528D-04  -0.60176D-03   0.12449D-05   0.75490D-04  -0.96571D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.56255D-05  -0.96319D-04  -0.75997D-03   0.14090D-05  -0.46537D-04   0.58498D-05                                                                                                
                                                                                                                                                                                                                            
MODE #18/ 56, Frequency (rad/sec), Damping (zeta), Generalized Mass=    71.777       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.19355D-05  -0.20661D-01  -0.53537D-03  -0.51937D-05  -0.32614D-04   0.12820D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.70557D-03   0.21949D-01   0.29535D-03   0.33270D-04  -0.89714D-04   0.45396D-03                                                                                                
Interstage Compartment           51980    -0.46342D-02   0.13081D-02   0.44203D-03  -0.40380D-03  -0.29910D-04  -0.79670D-03                                                                                                
Spacecraft Module (aft)          52930    -0.21544D-03   0.87279D-02   0.98970D-03   0.84568D-05   0.20752D-03  -0.22291D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.70557D-03   0.21949D-01   0.29535D-03                                                                                                                                          
Interstage Compartment           51980    -0.46342D-02   0.13081D-02   0.44203D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.21544D-03   0.87279D-02   0.98970D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.22665D-03  -0.19838D-01  -0.16460D-02   0.87444D-05   0.23870D-03  -0.25824D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.19355D-05  -0.20661D-01  -0.53537D-03  -0.51937D-05  -0.32614D-04   0.12820D-02                                                                                                
                                                                                                                                                                                                                            
MODE #19/ 67, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.870       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.83796D-03   0.15836D-03  -0.91324D-03   0.27691D-05  -0.59695D-04  -0.10337D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.88811D-03  -0.17754D-03   0.95678D-03  -0.11696D-05  -0.29736D-04   0.15019D-06                                                                                                
Interstage Compartment           51980    -0.33210D-03   0.38127D-03  -0.45139D-03  -0.43769D-04   0.21416D-04   0.15812D-04                                                                                                
Spacecraft Module (aft)          52930    -0.28845D-03  -0.15934D-03   0.14995D-02   0.18062D-06   0.28446D-03   0.32887D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.88811D-03  -0.17754D-03   0.95678D-03                                                                                                                                          
Interstage Compartment           51980    -0.33210D-03   0.38127D-03  -0.45139D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.28845D-03  -0.15934D-03   0.14995D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.30587D-03   0.26600D-03  -0.21604D-02   0.18769D-06   0.33494D-03   0.38886D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.83796D-03   0.15836D-03  -0.91324D-03   0.27691D-05  -0.59695D-04  -0.10337D-04                                                                                                
                                                                                                                                                                                                                            
MODE #20/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.875       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.37089D-03  -0.40153D-03   0.20020D-02  -0.59892D-05   0.13054D-03   0.26130D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.41434D-03   0.43446D-03  -0.20889D-02  -0.82812D-05  -0.22410D-04   0.86209D-05                                                                                                
Interstage Compartment           51980    -0.20144D-03  -0.59151D-03   0.10807D-02   0.10342D-03  -0.67093D-04   0.10755D-04                                                                                                
Spacecraft Module (aft)          52930     0.98143D-03   0.34918D-03  -0.31955D-02  -0.48936D-06  -0.60732D-03  -0.72035D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.41434D-03   0.43446D-03  -0.20889D-02                                                                                                                                          
Interstage Compartment           51980    -0.20144D-03  -0.59151D-03   0.10807D-02                                                                                                                                          
Spacecraft Module (aft)          52930     0.98143D-03   0.34918D-03  -0.31955D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.10407D-02  -0.58245D-03   0.46194D-02  -0.50850D-06  -0.71518D-03  -0.85176D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.37089D-03  -0.40153D-03   0.20020D-02  -0.59892D-05   0.13054D-03   0.26130D-04                                                                                                
------------------------------------------------------------------------------------------------------------------------                                                                                                    
SELECTED MODAL DATA AND LOCATIONS FOR THE PITCH MODES                                               
Apollo-20, Stage-1, Max-Q, 20 Flex modes, Pitch Modes, Stiff Interstage                                                                               
! The modes were selected by applying a force along the z direction at the gimbal and reading the                                                                                                                           
! pitch rotation at the stage-1 gyro and the Nz acceleration at the alpha sensor. They were                                                                                                                                 
! extracted from the increased stiffness FEM file "Apollo_Hard.Mod" and rescaled for units/directions                                                                                                                       
                                                                                                                                                                                                                            
MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.0734       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.57443D-05  -0.95961D-04   0.27897D-01  -0.81248D-05   0.50797D-03   0.18022D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.63119D-03  -0.73208D-05  -0.18390D-01   0.16039D-05  -0.12060D-03   0.17870D-04                                                                                                
Interstage Compartment           51980     0.98311D-03   0.47303D-05  -0.10636D-01  -0.97459D-05  -0.28534D-03  -0.92478D-06                                                                                                
Spacecraft Module (aft)          52930     0.66272D-05  -0.12855D-03   0.42129D-01  -0.99518D-05  -0.79594D-03  -0.24983D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.63119D-03  -0.73208D-05  -0.18390D-01                                                                                                                                          
Interstage Compartment           51980     0.98311D-03   0.47303D-05  -0.10636D-01                                                                                                                                          
Spacecraft Module (aft)          52930     0.66272D-05  -0.12855D-03   0.42129D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.66316D-05  -0.15748D-03   0.51348D-01  -0.99560D-05  -0.80129D-03  -0.25147D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.57443D-05  -0.95961D-04   0.27897D-01  -0.81248D-05   0.50797D-03   0.18022D-05                                                                                                
                                                                                                                                                                                                                            
MODE # 2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.2787       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.41966D-04   0.28117D-01   0.90973D-04  -0.29740D-06   0.16103D-05  -0.51558D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.60828D-04  -0.18000D-01  -0.22347D-04  -0.87983D-05   0.90682D-05   0.11755D-03                                                                                                
Interstage Compartment           51980     0.23963D-02  -0.10559D-01  -0.30004D-04  -0.44957D-06  -0.93919D-06   0.26864D-03                                                                                                
Spacecraft Module (aft)          52930     0.15652D-03   0.42272D-01   0.15649D-03  -0.34441D-06  -0.29123D-05   0.80666D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.60828D-04  -0.18000D-01  -0.22347D-04                                                                                                                                          
Interstage Compartment           51980     0.23963D-02  -0.10559D-01  -0.30004D-04                                                                                                                                          
Spacecraft Module (aft)          52930     0.15652D-03   0.42272D-01   0.15649D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.15663D-03   0.51619D-01   0.19024D-03  -0.34457D-06  -0.29332D-05   0.81234D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.41966D-04   0.28117D-01   0.90973D-04  -0.29740D-06   0.16103D-05  -0.51558D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    17.383       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.13362D-04   0.38943D-02   0.23675D-01   0.49405D-05   0.64489D-03  -0.10588D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.24323D-02  -0.18104D-03  -0.12543D-02  -0.39337D-04  -0.46948D-03   0.77630D-04                                                                                                
Interstage Compartment           51980     0.21600D-02   0.22278D-02   0.13870D-01  -0.75365D-05  -0.44465D-03   0.72562D-04                                                                                                
Spacecraft Module (aft)          52930     0.70205D-05  -0.46662D-02  -0.28991D-01  -0.83599D-05   0.11887D-02  -0.19276D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.24323D-02  -0.18104D-03  -0.12543D-02                                                                                                                                          
Interstage Compartment           51980     0.21600D-02   0.22278D-02   0.13870D-01                                                                                                                                          
Spacecraft Module (aft)          52930     0.70205D-05  -0.46662D-02  -0.28991D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.70400D-05  -0.69289D-02  -0.42946D-01  -0.83761D-05   0.12116D-02  -0.19646D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.13362D-04   0.38943D-02   0.23675D-01   0.49405D-05   0.64489D-03  -0.10588D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    17.505       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.12894D-04  -0.23936D-01   0.38846D-02   0.97756D-06   0.10632D-03   0.65392D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.88091D-03   0.81019D-03  -0.39946D-04   0.18013D-04  -0.10744D-03  -0.46387D-03                                                                                                
Interstage Compartment           51980    -0.35180D-02  -0.14375D-01   0.23560D-02  -0.10812D-05  -0.73321D-04  -0.45016D-03                                                                                                
Spacecraft Module (aft)          52930    -0.19841D-04   0.28686D-01  -0.47500D-02  -0.11822D-05   0.19729D-03   0.11977D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.88091D-03   0.81019D-03  -0.39946D-04                                                                                                                                          
Interstage Compartment           51980    -0.35180D-02  -0.14375D-01   0.23560D-02                                                                                                                                          
Spacecraft Module (aft)          52930    -0.19841D-04   0.28686D-01  -0.47500D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.19901D-04   0.42748D-01  -0.70665D-02  -0.11845D-05   0.20112D-03   0.12209D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.12894D-04  -0.23936D-01   0.38846D-02   0.97756D-06   0.10632D-03   0.65392D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    34.660       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.12033D-04   0.57678D-03  -0.29347D-01  -0.10865D-04  -0.11679D-02  -0.23491D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195     0.32632D-03   0.38118D-03  -0.26264D-01   0.94501D-05  -0.93290D-04   0.61216D-04                                                                                                
Interstage Compartment           51980     0.20150D-02   0.11614D-03  -0.98732D-02  -0.16280D-04  -0.62276D-03  -0.12727D-04                                                                                                
Spacecraft Module (aft)          52930     0.62662D-06   0.28295D-03  -0.80565D-02  -0.25490D-04   0.86116D-03   0.27034D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195     0.32632D-03   0.38118D-03  -0.26264D-01                                                                                                                                          
Interstage Compartment           51980     0.20150D-02   0.11614D-03  -0.98732D-02                                                                                                                                          
Spacecraft Module (aft)          52930     0.62662D-06   0.28295D-03  -0.80565D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.63137D-06   0.61112D-03  -0.18484D-01  -0.25688D-04   0.90682D-03   0.28522D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.12033D-04   0.57678D-03  -0.29347D-01  -0.10865D-04  -0.11679D-02  -0.23491D-04                                                                                                
                                                                                                                                                                                                                            
MODE # 6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    36.154       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.30088D-03   0.31804D-01   0.95639D-03   0.86472D-07   0.38359D-04  -0.12968D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.22453D-03   0.27568D-01   0.76320D-03   0.51271D-04  -0.60280D-04  -0.16393D-03                                                                                                
Interstage Compartment           51980    -0.67574D-02   0.75349D-02   0.26895D-03   0.12034D-05   0.20804D-04  -0.71137D-03                                                                                                
Spacecraft Module (aft)          52930    -0.10779D-02   0.48137D-02  -0.49258D-04   0.13681D-05  -0.23168D-05   0.76745D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.22453D-03   0.27568D-01   0.76320D-03                                                                                                                                          
Interstage Compartment           51980    -0.67574D-02   0.75349D-02   0.26895D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.10779D-02   0.48137D-02  -0.49258D-04                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.10916D-02   0.14080D-01  -0.23184D-04   0.13796D-05  -0.23128D-05   0.80734D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.30088D-03   0.31804D-01   0.95639D-03   0.86472D-07   0.38359D-04  -0.12968D-02                                                                                                
                                                                                                                                                                                                                            
MODE # 7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    41.140       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599    -0.19255D-03  -0.94846D-03   0.13168D-01  -0.98554D-05   0.57973D-03   0.42038D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.12998D-02  -0.62160D-03   0.98887D-02   0.39514D-04   0.27251D-03  -0.58609D-05                                                                                                
Interstage Compartment           51980    -0.11013D-02   0.51433D-03  -0.38355D-02   0.20905D-04   0.42611D-03   0.36222D-04                                                                                                
Spacecraft Module (aft)          52930     0.48582D-03   0.26448D-03  -0.66039D-02   0.42485D-04   0.54601D-03  -0.34229D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.12998D-02  -0.62160D-03   0.98887D-02                                                                                                                                          
Interstage Compartment           51980    -0.11013D-02   0.51433D-03  -0.38355D-02                                                                                                                                          
Spacecraft Module (aft)          52930     0.48582D-03   0.26448D-03  -0.66039D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.49383D-03   0.23368D-03  -0.13421D-01   0.42950D-04   0.59165D-03  -0.29206D-05                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599    -0.19255D-03  -0.94846D-03   0.13168D-01  -0.98554D-05   0.57973D-03   0.42038D-04                                                                                                
                                                                                                                                                                                                                            
MODE # 8/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    53.675       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.99876D-02  -0.21932D-02   0.42361D-03   0.30428D-05   0.20681D-04   0.11308D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.54618D-02   0.70654D-03  -0.31629D-03   0.16793D-04   0.22964D-04  -0.53881D-05                                                                                                
Interstage Compartment           51980    -0.87834D-02   0.41798D-03  -0.60637D-03  -0.15150D-05   0.17336D-04  -0.25212D-04                                                                                                
Spacecraft Module (aft)          52930    -0.26206D-01   0.20678D-04  -0.13486D-03  -0.78994D-05   0.31189D-05   0.16982D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.54618D-02   0.70654D-03  -0.31629D-03                                                                                                                                          
Interstage Compartment           51980    -0.87834D-02   0.41798D-03  -0.60637D-03                                                                                                                                          
Spacecraft Module (aft)          52930    -0.26206D-01   0.20678D-04  -0.13486D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091    -0.26951D-01   0.23306D-03  -0.18290D-03  -0.80476D-05   0.40458D-05   0.18691D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.99876D-02  -0.21932D-02   0.42361D-03   0.30428D-05   0.20681D-04   0.11308D-03                                                                                                
                                                                                                                                                                                                                            
MODE # 9/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    66.535       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
Stage-1 Rocket Engine pivot      51599     0.88542D-03   0.18857D-01   0.51738D-03   0.72440D-06   0.29834D-04  -0.11135D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
Stage-1 Rocket Booster gyro        195    -0.68195D-04  -0.15316D-01   0.23117D-03   0.60142D-04  -0.22444D-04  -0.44398D-03                                                                                                
Interstage Compartment           51980     0.17272D-02  -0.15069D-01  -0.11888D-03   0.35936D-06  -0.15298D-04   0.20972D-03                                                                                                
Spacecraft Module (aft)          52930     0.27023D-03   0.64944D-02   0.45117D-03  -0.30186D-05   0.12902D-03  -0.21572D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...                                                                                                                            
Stage-1 Rocket Booster gyro        195    -0.68195D-04  -0.15316D-01   0.23117D-03                                                                                                                                          
Interstage Compartment           51980     0.17272D-02  -0.15069D-01  -0.11888D-03                                                                                                                                          
Spacecraft Module (aft)          52930     0.27023D-03   0.64944D-02   0.45117D-03                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Vanes (for alpha,beta measurem)...                                                                                                                          
Spacecraft Module (forward)      53091     0.28227D-03  -0.20873D-01  -0.11786D-02  -0.31063D-05   0.14614D-03  -0.24516D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Stage-1 Rocket Engine pivot      51599     0.88542D-03   0.18857D-01   0.51738D-03   0.72440D-06   0.29834D-04  -0.11135D-02                                                                                                
                                                                                                                                                                                                                            
MODE #10/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    66.721       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
