BATCH MODE INSTRUCTIONS ...............                                                             
Batch set for Generating the Apollo RCS models                                                                                             
! This set of batch instructions calculates the Apollo launch vehicle roll axis
! state-space models for both rigid and flex structures. 
!
Flight Vehicle   : Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control
Flight Vehicle   : Apollo-20, Stage-1, Max-Q, Flex Body, RCS Control
System Modificat : Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control, Roll Axis
System Modificat : Apollo-20, Stage-1, Max-Q, Flex Body, RCS Control, Roll Axis
!
To Matlab Format : Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control, Roll Axis
To Matlab Format : Apollo-20, Stage-1, Max-Q, Flex Body, RCS Control, Roll Axis
---------------------------------------------------------------------------------------------------------------------------------------------                                                                               
FLIGHT VEHICLE INPUT DATA ......
Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control
Body Axes Output, Attitude=Euler Angles,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   40400.0      32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   930400.0     2.163e8      2.163e8     -1.8e4,  1.9e3,  -5.4e3    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -194.0513    -0.01        -0.01336
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.6          1491.0       840.0        35000.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   70.000       64.400       0.0000       0.000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0000       0.0000       0.0000       0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       53.000       0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehicle (Azim & Elev) angles, or Force (lb), location, Torque (ft-lb)  :   Gust         0.0          90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   255.73      243.2         243.2  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -305.00      0.0000        0.0          0.0
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   1.0500      0.027         0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0000     -0.0637        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0091     -0.0637        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0000      0.0           0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.0076      0.0506        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0000     -0.000         0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Single TVC       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  2850000.0    2850000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.00000      0.0000      5.0000       5.0000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        6383.0     -0.7    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -307.64       0.0         0.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Upper Jet        Throttling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0          600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          90.0        0.0          0.0  
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0          0.0        -0.0    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -106.968      0.0        -9.854
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right Jet        Throttling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0          600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -90.0         0.0         0.0          0.0  
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0          0.0         0.0    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -106.968      9.854       0.0
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Lower Jet        Throttling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0          600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0         -90.0        0.0          0.0  
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0          0.0        -0.0    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -106.968      0.0         9.854
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left  Jet        Throttling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0          600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  90.0         0.0         0.0          0.0  
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0          0.0         0.0    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -106.968     -9.854       0.0

Number of Gyros, (Attitude and Rate)                                                     :  2
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location (Top SRB) :  Roll  Rate            -166.72        0.00000        0.00000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location (Aft Stg2):  Roll  Rate             -46.87        0.00000        0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  0

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  :  0
                                                                                                    
---------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Apollo-20, Stage-1, Max-Q, Flex Body, RCS Control
Body Axes Output, Attitude=Euler Angles,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   40400.0      32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   930400.0     2.163e8      2.163e8     -1.8e4,  1.9e3,  -5.4e3    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -194.0513    -0.01        -0.01336
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.6          1491.0       840.0        35000.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   70.000       64.400       0.0000       0.000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0000       0.0000       0.0000       0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       53.000       0.0000       0.0000       0.0000       0.0000    
Wind Gust Direction Relative to the Vehicle in Azimuth and Elevation Angles (deg)        :   Gust         0.000        90.000    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   255.73      243.2         243.2  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -305.00      0.0000        0.0          0.0
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   1.0500      0.027         0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0000     -0.0637        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0091     -0.0637        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0000      0.0           0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.0076      0.0506        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0000     -0.000         0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Single TVC       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  2850000.0    2850000.4
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.00000      0.0000      5.0000       5.0000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        6383.0     -0.7    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -307.64       0.0         0.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Upper Jet        Throttling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0          600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          90.0        0.0          0.0  
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0          0.0        -0.0    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -106.968      0.0        -9.854
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right Jet        Throttling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0          600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -90.0         0.0         0.0          0.0  
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0          0.0         0.0    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -106.968      9.854       0.0
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Lower Jet        Throttling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0          600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0         -90.0        0.0          0.0  
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0          0.0        -0.0    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -106.968      0.0         9.854
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left  Jet        Throttling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0          600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  90.0         0.0         0.0          0.0  
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0          0.0         0.0    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -106.968     -9.854       0.0

Number of Gyros, (Attitude and Rate)                                                     :  2
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location (Top SRB) :  Roll  Rate            -166.72        0.00000        0.00000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location (Aft Stg2):  Roll  Rate             -46.87        0.00000        0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  0

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  : 20
Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control, Roll Modes                                             
---------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control, Roll Axis
Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control                           
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   5   6   7   8
Extract States :   1   2 
Extract Outputs:   1   2
---------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Apollo-20, Stage-1, Max-Q, Flex Body, RCS Control, Roll Axis
Apollo-20, Stage-1, Max-Q, Flex Body, RCS Control
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   5   6   7   8
Extract States :   1   2  11  12  13  14  15  16  17  18  19  20  21  22  23  24  25  26  27  28  29  30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50
Extract Outputs:   1   2  12  13
---------------------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR THE ROLL MODES          
Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control, Roll Modes                                             
! The following set of modes were selected from the modal data file by applying four 
! forces at the four RCS jets in the direction that excites roll. The motion is sensed 
! the gyros in the roll direction

MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.3352       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599     0.53880D-05  -0.71862D-04   0.26600D-01  -0.88775D-05   0.47057D-03   0.13150D-05
Upper RCS Jet                    65001     0.52242D-02  -0.93058D-04  -0.36325D-03   0.11318D-05  -0.54564D-03  -0.19652D-05
Right RCS Jet                    65002     0.81439D-05   0.19665D-04  -0.56220D-03  -0.36191D-04  -0.53323D-03   0.62080D-05
Lower RCS Jet                    65003    -0.51906D-02   0.12106D-03  -0.38125D-03  -0.21497D-04  -0.53052D-03  -0.11763D-05
Left  RCS Jet                    65004    -0.64290D-05   0.10389D-04  -0.34981D-03   0.18247D-04  -0.53244D-03   0.96439D-06

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.19430D-03  -0.11673D-04  -0.19410D-01  -0.29114D-05  -0.39856D-04   0.17504D-04
Space Module stage aft CL        52930     0.61977D-05  -0.10425D-03   0.42950D-01  -0.10998D-04  -0.79624D-03  -0.20076D-05

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700     0.59722D-05  -0.11518D-04   0.60963D-02  -0.10882D-04  -0.61193D-03  -0.15016D-05

MODE # 2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.4826       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.32466D-04   0.26720D-01   0.68351D-04  -0.47449D-06   0.11679D-05  -0.47489D-03
Upper RCS Jet                    65001     0.13503D-03  -0.60466D-03   0.26228D-05  -0.11746D-04  -0.10790D-05   0.53017D-03
Right RCS Jet                    65002    -0.50548D-02  -0.51891D-03   0.76658D-05   0.43285D-05  -0.14896D-05   0.53592D-03
Lower RCS Jet                    65003     0.10463D-03  -0.61102D-03   0.46821D-05   0.10557D-04  -0.26158D-05   0.53021D-03
Left  RCS Jet                    65004     0.52991D-02  -0.52037D-03  -0.39061D-06  -0.19926D-05  -0.14741D-05   0.53785D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.16618D-05  -0.19165D-01  -0.46174D-05  -0.60050D-05   0.12101D-04   0.33056D-04
Space Module stage aft CL        52930     0.12176D-03   0.43114D-01   0.12608D-03   0.37338D-06  -0.23052D-05   0.80504D-03

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700     0.12099D-03   0.59231D-02   0.19769D-04   0.36932D-06  -0.17516D-05   0.61252D-03

MODE # 3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    16.975       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.12612D-04  -0.39464D-02  -0.24607D-01  -0.48068D-05  -0.66061D-03   0.10574D-03
Upper RCS Jet                    65001     0.12986D-02  -0.35916D-02  -0.21898D-01  -0.28176D-03  -0.18730D-03   0.19520D-04
Right RCS Jet                    65002    -0.23959D-03  -0.39658D-02  -0.21496D-01   0.37997D-03  -0.13530D-03   0.44268D-04
Lower RCS Jet                    65003    -0.12534D-02  -0.36583D-02  -0.20798D-01   0.88999D-04  -0.15972D-03   0.24488D-04
Left  RCS Jet                    65004     0.19525D-03  -0.32254D-02  -0.21740D-01  -0.18056D-03  -0.13163D-03   0.41598D-04

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.25719D-02   0.25439D-03   0.17576D-02   0.39025D-04   0.49577D-03  -0.83228D-04
Space Module stage aft CL        52930    -0.99730D-05   0.43137D-02   0.27576D-01   0.87246D-05  -0.11256D-02   0.17741D-03

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.88031D-05  -0.29947D-02  -0.18736D-01   0.82356D-05  -0.40036D-03   0.63217D-04

MODE # 4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    17.092       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.19382D-04   0.24932D-01  -0.39360D-02  -0.10643D-05  -0.10616D-03  -0.67114D-03
Upper RCS Jet                    65001     0.23060D-03   0.22473D-01  -0.35252D-02   0.22825D-04  -0.17678D-04  -0.13568D-03
Right RCS Jet                    65002     0.12755D-02   0.22164D-01  -0.35535D-02   0.84146D-05  -0.21653D-04  -0.14837D-03
Lower RCS Jet                    65003    -0.16257D-03   0.22443D-01  -0.35165D-02  -0.19778D-04  -0.30118D-04  -0.13644D-03
Left  RCS Jet                    65004    -0.11799D-02   0.22166D-01  -0.35827D-02  -0.92732D-05  -0.22400D-04  -0.14323D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.92451D-03  -0.13033D-02   0.10962D-03  -0.19056D-04   0.11087D-03   0.49010D-03
Space Module stage aft CL        52930     0.44642D-04  -0.27211D-01   0.43956D-02   0.16189D-05  -0.18179D-03  -0.11312D-02

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700     0.43329D-04   0.19329D-01  -0.30752D-02   0.15266D-05  -0.64292D-04  -0.40148D-03

MODE # 5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    33.423       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.70579D-05   0.46670D-03  -0.29274D-01  -0.11920D-04  -0.11387D-02  -0.18661D-04
Upper RCS Jet                    65001     0.51268D-02   0.45029D-03   0.12421D-01   0.13284D-02  -0.64094D-03  -0.33778D-04
Right RCS Jet                    65002    -0.27498D-03   0.18649D-02   0.10352D-01  -0.18840D-02  -0.53214D-03   0.25190D-03
Lower RCS Jet                    65003    -0.44623D-02   0.57688D-03   0.84207D-02  -0.76128D-03  -0.66122D-04  -0.11768D-04
Left  RCS Jet                    65004    -0.11439D-03  -0.55457D-03   0.11009D-01   0.14942D-02  -0.50701D-03   0.52481D-04

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.69665D-03   0.34752D-03  -0.27905D-01  -0.16694D-05   0.97514D-04   0.61840D-04
Space Module stage aft CL        52930    -0.10484D-04   0.27813D-03  -0.89575D-02  -0.29740D-04   0.89802D-03   0.25330D-04

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.31918D-04  -0.43031D-03   0.17026D-01  -0.23267D-04  -0.30893D-03  -0.70997D-05

MODE # 6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    34.582       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.25613D-03  -0.31022D-01  -0.77171D-03  -0.21833D-05  -0.30029D-04   0.12305D-02
Upper RCS Jet                    65001     0.81546D-03   0.15367D-01   0.26757D-03   0.55498D-04   0.14747D-04   0.48478D-03
Right RCS Jet                    65002    -0.38621D-02   0.15117D-01   0.18892D-03  -0.29028D-04  -0.43870D-05   0.44633D-03
Lower RCS Jet                    65003     0.71731D-03   0.15270D-01   0.57587D-04   0.37246D-06  -0.24342D-04   0.48038D-03
Left  RCS Jet                    65004     0.55450D-02   0.14932D-01   0.13163D-03  -0.21536D-04  -0.83189D-05   0.49906D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.27859D-03  -0.29254D-01  -0.61189D-03  -0.38304D-04   0.72122D-04  -0.68123D-04
Space Module stage aft CL        52930     0.95422D-03  -0.61851D-02   0.33576D-04   0.54516D-05   0.17524D-05  -0.83470D-03

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700     0.82560D-03   0.19546D-01   0.18157D-03   0.41890D-05   0.10275D-05   0.23090D-03

MODE # 7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    40.804       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.27189D-03  -0.79370D-03   0.11975D-01  -0.12397D-04   0.52446D-03   0.35012D-04
Upper RCS Jet                    65001     0.45543D-02   0.36191D-02  -0.66058D-02   0.30594D-02  -0.10839D-02  -0.98176D-04
Right RCS Jet                    65002    -0.10128D-02   0.52346D-02  -0.98587D-02  -0.41849D-02  -0.41280D-03   0.11088D-02
Lower RCS Jet                    65003    -0.37250D-03   0.25168D-02  -0.13641D-01  -0.22850D-02   0.13094D-02   0.12708D-04
Left  RCS Jet                    65004     0.73104D-03   0.17912D-02  -0.10269D-01   0.42971D-02  -0.29496D-03   0.43766D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.10543D-02  -0.57035D-03   0.93713D-02   0.42022D-04   0.22385D-03  -0.11622D-04
Space Module stage aft CL        52930     0.77560D-03   0.29391D-03  -0.71149D-02   0.50486D-04   0.62174D-03   0.26009D-05

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700     0.53173D-03   0.74154D-03  -0.18541D-03   0.34446D-04  -0.59556D-03  -0.17695D-04

MODE # 8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    48.590       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599     0.90984D-02  -0.14943D-02   0.51988D-03  -0.46026D-04   0.24271D-04   0.72538D-04
Upper RCS Jet                    65001    -0.19949D-01   0.10309D-02  -0.28124D-03   0.29107D-03   0.85088D-03   0.12344D-04
Right RCS Jet                    65002    -0.20178D-01   0.44988D-03  -0.43286D-03  -0.27355D-03  -0.21924D-04   0.87679D-03
Lower RCS Jet                    65003    -0.20157D-01  -0.14162D-03  -0.16281D-02  -0.48746D-04  -0.82205D-03   0.77447D-05
Left  RCS Jet                    65004    -0.19955D-01   0.48728D-03  -0.14889D-02   0.28394D-03  -0.18024D-04  -0.83651D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.28731D-02  -0.34528D-04  -0.61381D-04   0.27062D-04   0.40199D-04  -0.44015D-04
Space Module stage aft CL        52930    -0.28013D-01  -0.65337D-05  -0.20486D-03   0.11898D-03   0.14785D-04  -0.17612D-04

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.20552D-01   0.43313D-03  -0.40411D-03   0.64758D-04  -0.30980D-04   0.79370D-05

MODE # 9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    48.695       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599     0.13812D-03  -0.79866D-04  -0.29007D-05   0.29926D-02  -0.10944D-06   0.36827D-05
Upper RCS Jet                    65001    -0.37003D-03  -0.35899D-01  -0.22566D-03  -0.36347D-02   0.12947D-04  -0.12688D-03
Right RCS Jet                    65002    -0.32542D-03   0.47632D-04  -0.36186D-01  -0.36906D-02   0.13361D-03   0.24248D-04
Lower RCS Jet                    65003    -0.21337D-03   0.35980D-01  -0.27564D-03  -0.36787D-02   0.94963D-05   0.12703D-03
Left  RCS Jet                    65004    -0.29906D-03   0.44329D-04   0.35682D-01  -0.36240D-02  -0.11952D-03  -0.71850D-05

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.10837D-03  -0.31739D-02   0.58485D-03  -0.24114D-03  -0.11800D-04   0.42322D-04
Space Module stage aft CL        52930    -0.42735D-03   0.17760D-05  -0.23937D-04  -0.77466D-02  -0.53597D-05  -0.72968D-06

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.31412D-03   0.25619D-04  -0.25848D-03  -0.42005D-02   0.29214D-06   0.11959D-06

MODE #10/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.624       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599     0.48159D-03   0.22621D-01   0.72982D-03   0.28717D-05   0.41174D-04  -0.12988D-02
Upper RCS Jet                    65001     0.67715D-03   0.13418D-01   0.91464D-03  -0.25918D-03  -0.13014D-03   0.16105D-02
Right RCS Jet                    65002    -0.14444D-01   0.13189D-01   0.14547D-02   0.36391D-03  -0.78522D-04   0.16890D-02
Lower RCS Jet                    65003    -0.82202D-03   0.13524D-01   0.19169D-02   0.59546D-04  -0.94153D-04   0.16178D-02
Left  RCS Jet                    65004     0.14152D-01   0.13836D-01   0.13836D-02  -0.17676D-03  -0.73241D-04   0.16606D-02

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.53724D-03  -0.17355D-01   0.25312D-03   0.86822D-04  -0.38975D-04  -0.83638D-03
Space Module stage aft CL        52930    -0.24621D-03   0.52636D-02   0.34780D-03  -0.78077D-05   0.12410D-03  -0.22124D-02

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.13370D-03   0.35809D-01   0.22918D-02  -0.17156D-05  -0.86724D-04   0.17786D-02

MODE #11/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.645       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.37296D-04   0.30378D-02   0.10845D-03   0.37890D-06   0.61429D-05  -0.17444D-03
Upper RCS Jet                    65001    -0.81341D-05   0.18111D-02   0.12458D-03  -0.32956D-04  -0.63934D-05   0.21749D-03
Right RCS Jet                    65002    -0.20506D-02   0.17793D-02   0.18928D-03   0.46190D-04  -0.10852D-04   0.23872D-03
Lower RCS Jet                    65003    -0.21428D-03   0.18247D-02   0.24422D-03   0.75697D-05  -0.23887D-04   0.21842D-03
Left  RCS Jet                    65004     0.18096D-02   0.18683D-02   0.18041D-03  -0.22420D-04  -0.10185D-04   0.21314D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.18030D-03  -0.23302D-02   0.22720D-04   0.12080D-04  -0.39108D-05  -0.11342D-03
Space Module stage aft CL        52930    -0.22601D-03   0.71227D-03   0.46614D-04  -0.10801D-05   0.16860D-04  -0.29882D-03

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.12380D-03   0.48343D-02   0.30761D-03  -0.23675D-06  -0.11968D-04   0.24029D-03

MODE #12/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    64.106       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.25966D-02   0.15964D-02   0.21718D-03   0.83849D-07   0.12901D-04  -0.91925D-04
Upper RCS Jet                    65001    -0.10911D-02   0.10640D-02   0.10279D-03   0.28331D-05   0.12281D-03   0.12973D-03
Right RCS Jet                    65002    -0.23209D-02   0.10362D-02   0.47307D-04  -0.50465D-05  -0.10143D-04   0.26270D-03
Lower RCS Jet                    65003    -0.12739D-02   0.10643D-02  -0.48033D-05   0.43688D-06  -0.14317D-03   0.12965D-03
Left  RCS Jet                    65004    -0.37930D-04   0.11058D-02   0.50567D-04   0.14791D-05  -0.10328D-04   0.37024D-06

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.13544D-02  -0.12202D-02  -0.16275D-03   0.10882D-04   0.85775D-05  -0.72812D-04
Space Module stage aft CL        52930    -0.22821D-02   0.44353D-03   0.27390D-04  -0.10730D-05   0.12010D-04  -0.17892D-03

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.12373D-02   0.28636D-02   0.18465D-03  -0.22282D-06  -0.10524D-04   0.14462D-03

MODE #13/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.327       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599     0.76628D-04   0.54738D-03  -0.26287D-01   0.23401D-04  -0.15703D-02  -0.33523D-04
Upper RCS Jet                    65001    -0.47172D-02   0.99295D-03  -0.88419D-02   0.28231D-03   0.36410D-03   0.18037D-04
Right RCS Jet                    65002    -0.41671D-03   0.24317D-03  -0.84446D-02  -0.36761D-03   0.51167D-03   0.19508D-03
Lower RCS Jet                    65003     0.58601D-02   0.11625D-02  -0.84737D-02  -0.67753D-03   0.10507D-02   0.37025D-04
Left  RCS Jet                    65004     0.77987D-03   0.24109D-02  -0.85941D-02   0.78416D-03   0.53711D-03   0.38917D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.39793D-02  -0.50782D-03   0.24064D-01  -0.17400D-03  -0.76626D-03  -0.93284D-04
Space Module stage aft CL        52930     0.49022D-03   0.20836D-03  -0.21918D-02   0.74731D-04  -0.50297D-03  -0.51289D-04

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700     0.19301D-03   0.11020D-02  -0.12913D-01   0.95365D-05   0.31456D-03   0.31566D-04

MODE #14/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.352       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.43791D-05   0.32127D-03  -0.13782D-01   0.12331D-04  -0.82352D-03  -0.19615D-04
Upper RCS Jet                    65001    -0.32932D-02   0.52052D-03  -0.46757D-02   0.16972D-03   0.29212D-03   0.86454D-05
Right RCS Jet                    65002    -0.10183D-02   0.11870D-03  -0.45378D-02  -0.22423D-03   0.26821D-03   0.19654D-03
Lower RCS Jet                    65003     0.22542D-02   0.60308D-03  -0.46293D-02  -0.36212D-03   0.44353D-03   0.18121D-04
Left  RCS Jet                    65004    -0.40069D-03   0.12622D-02  -0.46090D-02   0.42841D-03   0.28110D-03   0.11619D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.21477D-02  -0.30000D-03   0.12627D-01  -0.91177D-04  -0.39964D-03  -0.49531D-04
Space Module stage aft CL        52930    -0.14962D-02   0.10227D-03  -0.11643D-02   0.39094D-04  -0.26543D-03  -0.24757D-04

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.76957D-03   0.54543D-03  -0.68513D-02   0.49639D-05   0.16412D-03   0.14971D-04

MODE #15/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.931       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.16076D-04  -0.42496D-04  -0.11399D-02   0.16476D-05  -0.69798D-04   0.25546D-05
Upper RCS Jet                    65001    -0.24543D-02   0.28066D-02  -0.12448D-01   0.35510D-02   0.24902D-02  -0.24334D-04
Right RCS Jet                    65002    -0.27165D-02   0.12212D-01  -0.38201D-02  -0.49399D-02  -0.55716D-04   0.25176D-02
Lower RCS Jet                    65003    -0.70615D-03   0.27080D-02   0.13362D-02  -0.34122D-02  -0.53783D-03  -0.15244D-04
Left  RCS Jet                    65004    -0.10578D-02  -0.40281D-02  -0.37329D-02   0.48590D-02  -0.46204D-04  -0.10040D-02

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.14688D-03   0.40525D-04   0.11332D-02  -0.49246D-05  -0.24460D-04  -0.29171D-05
Space Module stage aft CL        52930    -0.49993D-04   0.18614D-04   0.16851D-03   0.24186D-05   0.51144D-04  -0.44575D-05

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.26106D-04   0.74142D-04   0.52466D-03  -0.13817D-05  -0.45163D-04   0.34872D-05

MODE #16/ 62, Frequency (rad/sec), Damping (zeta), Generalized Mass=    73.632       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.51716D-05  -0.20623D-01  -0.44029D-03  -0.22854D-05  -0.27155D-04   0.13009D-02
Upper RCS Jet                    65001     0.14320D-02   0.37285D-02   0.22952D-02  -0.95124D-03  -0.42559D-03   0.13108D-02
Right RCS Jet                    65002    -0.10857D-01   0.36352D-02   0.35183D-02   0.12050D-02  -0.12350D-03   0.13514D-02
Lower RCS Jet                    65003    -0.11474D-02   0.39734D-02   0.48427D-02   0.44590D-03  -0.11813D-03   0.13309D-02
Left  RCS Jet                    65004     0.10539D-01   0.48339D-02   0.33179D-02  -0.71068D-03  -0.10561D-03   0.13169D-02

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.52157D-03   0.21532D-01   0.32313D-03   0.49076D-04  -0.11250D-03   0.27413D-03
Space Module stage aft CL        52930    -0.29146D-03   0.94700D-02   0.11871D-02   0.47668D-05   0.23288D-03  -0.22247D-02

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.10532D-03   0.26888D-01   0.44471D-02  -0.22768D-06  -0.14629D-03   0.19524D-02

MODE #17/ 67, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.879       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599     0.79775D-03  -0.41864D-04  -0.95812D-04   0.29204D-06  -0.63696D-05   0.26906D-05
Upper RCS Jet                    65001     0.47593D-03  -0.14384D-03   0.12930D-02  -0.17514D-03  -0.26946D-03  -0.28903D-05
Right RCS Jet                    65002     0.95178D-06   0.55038D-03   0.45912D-03   0.26725D-03  -0.19163D-04   0.26641D-04
Lower RCS Jet                    65003    -0.52676D-04  -0.26093D-03   0.14657D-03   0.33385D-03   0.59803D-04   0.17146D-05
Left  RCS Jet                    65004    -0.12001D-03  -0.12018D-02   0.56916D-03  -0.40474D-03  -0.14497D-04  -0.12108D-03

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.84681D-03   0.33291D-04   0.10966D-03  -0.40645D-05  -0.31253D-04   0.46369D-05
Space Module stage aft CL        52930     0.16251D-03  -0.73941D-05   0.18062D-03   0.12907D-07   0.33846D-04   0.15233D-05

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700     0.58256D-04  -0.22002D-04   0.53738D-03  -0.41024D-07  -0.24648D-04  -0.13244D-05

MODE #18/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.934       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.15254D-04   0.67189D-03  -0.22658D-02   0.62930D-05  -0.14788D-03  -0.43722D-04
Upper RCS Jet                    65001     0.68772D-02  -0.26218D-02   0.24959D-01  -0.30684D-02  -0.39480D-02  -0.87835D-04
Right RCS Jet                    65002    -0.17538D-02   0.10898D-01   0.72647D-02   0.47521D-02  -0.34574D-03   0.17290D-02
Lower RCS Jet                    65003    -0.27659D-02  -0.50567D-02  -0.12340D-03   0.64548D-02   0.17576D-05  -0.49444D-05
Left  RCS Jet                    65004    -0.46838D-02  -0.23363D-01   0.95674D-02  -0.77194D-02  -0.26040D-03  -0.36823D-02

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.32240D-04  -0.70402D-03   0.23584D-02   0.69283D-05   0.11611D-04  -0.84469D-05
Space Module stage aft CL        52930    -0.92834D-03  -0.49246D-03   0.31142D-02   0.97350D-06   0.59628D-03   0.10197D-03

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.31306D-03  -0.11754D-02   0.88052D-02  -0.90842D-06  -0.45836D-03  -0.89662D-04

MODE #19/ 69, Frequency (rad/sec), Damping (zeta), Generalized Mass=    77.438       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599    -0.20912D-04   0.36416D-03   0.35860D-04   0.54251D-06   0.13634D-05  -0.22834D-04
Upper RCS Jet                    65001    -0.39246D-05  -0.96479D-05   0.25058D-04   0.14267D-04   0.10548D-04  -0.14104D-04
Right RCS Jet                    65002     0.12578D-03   0.33082D-04  -0.42611D-04  -0.19086D-04  -0.24491D-06  -0.17016D-04
Lower RCS Jet                    65003    -0.11101D-04  -0.48734D-06  -0.93150D-04  -0.25051D-06  -0.96620D-05  -0.15044D-04
Left  RCS Jet                    65004    -0.10226D-03  -0.60864D-04  -0.26975D-04   0.30073D-05  -0.82530D-06  -0.15122D-04

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195    -0.39925D-03  -0.41480D-03  -0.78297D-04   0.95341D-05   0.53750D-04   0.31546D-04
Space Module stage aft CL        52930     0.26202D-04  -0.13446D-03  -0.95977D-05   0.19170D-05  -0.15433D-05   0.27439D-04

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700     0.89117D-05  -0.28561D-03  -0.29182D-04  -0.29803D-06   0.48592D-06  -0.24628D-04

MODE #20/ 70, Frequency (rad/sec), Damping (zeta), Generalized Mass=    77.569       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-1 Rocket Engine pivot      51599     0.69413D-05   0.19870D-03  -0.11110D-03  -0.11951D-05  -0.62239D-05  -0.11825D-04
Upper RCS Jet                    65001    -0.39542D-06   0.24374D-04   0.15571D-03  -0.17972D-04  -0.27082D-04  -0.88602D-05
Right RCS Jet                    65002     0.32976D-04   0.13099D-03  -0.15204D-04   0.36587D-04   0.25444D-05   0.12917D-04
Lower RCS Jet                    65003     0.39518D-04  -0.78276D-04  -0.13770D-03   0.52543D-04   0.94938D-05  -0.53519D-05
Left  RCS Jet                    65004    -0.91019D-04  -0.23051D-03  -0.32659D-04  -0.55699D-04   0.46675D-05  -0.40332D-04

                              Node ID#     Modal Data at the  2 Gyros ...
Stage-1 Rocket Booster gyro        195     0.98466D-04  -0.22097D-03   0.14735D-03   0.40723D-05   0.66803D-05  -0.16482D-03
Space Module stage aft CL        52930    -0.18636D-06  -0.66299D-04  -0.16354D-04  -0.89860D-05  -0.23233D-05   0.13556D-04

                              Node ID#     Modal Data at the Disturbance Point 
Center of Pressure (CP) center   62700    -0.73549D-06  -0.13666D-03  -0.82543D-04   0.14232D-05   0.99822D-06  -0.12294D-04
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Apollo-20, Stage-1, Max-Q, Rigid Body, RCS Control, Roll Axis
System
vehi_roll_rb.m
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Apollo-20, Stage-1, Max-Q, Flex Body, RCS Control, Roll Axis
System
vehi_roll_flx.m
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
