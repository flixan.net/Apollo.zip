                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.56814D-02   0.10012D-01  -0.89212D-01   0.57647D-02  -0.44141D-02   0.11650D-01
S1 Engine No:2 +Y-Z               1152     0.40261D-01   0.24216D-02  -0.78808D-01  -0.13082D-01  -0.24481D-01   0.95918D-02
S1 Engine No:3 -Y-Z               1153     0.39957D-01  -0.78957D-03  -0.78878D-01   0.13225D-01  -0.24786D-01  -0.98742D-02
S1 Engine No:4 -Y-Z               1154     0.45310D-02  -0.86203D-02  -0.89553D-01  -0.57176D-02  -0.44128D-02  -0.12296D-01
S1 Engine No:5 -Y+Z               1155    -0.53177D-02   0.10585D-01  -0.89559D-01  -0.57701D-02  -0.43496D-02   0.11850D-01
S1 Engine No:6 -Y+Z               1156    -0.40161D-01   0.27815D-02  -0.78891D-01   0.13354D-01  -0.24534D-01   0.97633D-02
S1 Engine No:7 +Y+Z               1157    -0.40296D-01  -0.42769D-03  -0.78350D-01  -0.12938D-01  -0.24834D-01  -0.96218D-02
S1 Engine No:8 +Y+Z               1158    -0.46694D-02  -0.85204D-02  -0.89140D-01   0.51780D-02  -0.48160D-02  -0.12373D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01  -0.13799D-06   0.38954D-02   0.44483D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01  -0.13799D-06   0.38954D-02   0.44483D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01  -0.13799D-06   0.38954D-02   0.44483D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.34315D-05   0.19758D-03  -0.16952D-01   0.16406D-06  -0.78913D-02  -0.90274D-04
Fuel Slosh Mass Locat.             600    -0.84619D-05   0.11823D-02  -0.10369D+00  -0.70871D-06   0.70250D-02   0.81496D-04

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.19605D-04  -0.30963D-03   0.28244D-01   0.29117D-06   0.44068D-01   0.49698D-03

MODE# 32/ 57, Frequency (rad/sec), Damping (zeta), Generalized Mass=    492.66       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.13885D-01   0.98884D-02  -0.11631D-04   0.84175D-03   0.20712D-03  -0.36028D-02
S1 Engine No:2 +Y-Z               1152     0.10104D-01   0.10540D-01  -0.52880D-03  -0.36486D-03  -0.18400D-03  -0.18149D-02
S1 Engine No:3 -Y-Z               1153     0.72800D-02   0.10497D-01   0.64241D-03  -0.33072D-03  -0.16972D-02  -0.96530D-03
S1 Engine No:4 -Y-Z               1154     0.35647D-02   0.98381D-02   0.16192D-03   0.78724D-03  -0.99583D-03  -0.16974D-02
S1 Engine No:5 -Y+Z               1155     0.36636D-02   0.99171D-02  -0.17716D-04  -0.86503D-03   0.10986D-02  -0.16918D-02
S1 Engine No:6 -Y+Z               1156     0.74357D-02   0.10604D-01  -0.49901D-03   0.40591D-03   0.17508D-02  -0.88609D-03
S1 Engine No:7 +Y+Z               1157     0.10133D-01   0.10642D-01   0.81706D-03   0.38567D-03   0.16686D-03  -0.17760D-02
S1 Engine No:8 +Y+Z               1158     0.13908D-01   0.99344D-02   0.25808D-03  -0.89610D-03  -0.18024D-03  -0.36428D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04   0.17743D-06  -0.61448D-05   0.63956D-03
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04   0.17743D-06  -0.61448D-05   0.63956D-03
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04   0.17743D-06  -0.61448D-05   0.63956D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.12611D-01   0.85388D-02   0.81900D-04  -0.62132D-06   0.15614D-04  -0.16252D-02
Fuel Slosh Mass Locat.             600     0.33931D-01   0.77520D-02   0.75540D-04   0.68892D-05  -0.27342D-05   0.32128D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.15137D-02  -0.29552D-02  -0.28985D-04  -0.15269D-07  -0.54664D-04   0.56609D-02

MODE# 33/ 58, Frequency (rad/sec), Damping (zeta), Generalized Mass=    515.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.35969D-01  -0.14007D+00  -0.77955D-01  -0.48260D-02  -0.12668D-01   0.20172D-01
S1 Engine No:2 +Y-Z               1152     0.10148D-01  -0.14707D+00  -0.71499D-01  -0.40314D-03  -0.16549D-01   0.14050D-01
S1 Engine No:3 -Y-Z               1153     0.33527D-01  -0.14798D+00  -0.80561D-01   0.60634D-02   0.49602D-04   0.68711D-02
S1 Engine No:4 -Y-Z               1154     0.47944D-01  -0.14493D+00  -0.79252D-01  -0.78376D-02   0.13018D-02   0.11770D-01
S1 Engine No:5 -Y+Z               1155     0.35019D-01  -0.14056D+00  -0.77434D-01   0.54156D-02  -0.13070D-01   0.20452D-01
S1 Engine No:6 -Y+Z               1156    -0.11346D-01  -0.14782D+00  -0.70963D-01  -0.36656D-03  -0.17014D-01   0.13202D-01
S1 Engine No:7 +Y+Z               1157    -0.33439D-01  -0.14865D+00  -0.81545D-01  -0.61714D-02   0.71434D-03   0.65328D-02
S1 Engine No:8 +Y+Z               1158    -0.48518D-01  -0.14503D+00  -0.79744D-01   0.81565D-02   0.13423D-02   0.12221D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02   0.37814D-08  -0.53273D-03   0.10004D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02   0.37814D-08  -0.53273D-03   0.10004D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02   0.37814D-08  -0.53273D-03   0.10004D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.16109D-02   0.33624D-01   0.17914D-01  -0.13241D-07   0.15137D-02  -0.28398D-02
Fuel Slosh Mass Locat.             600    -0.36034D-02  -0.87273D-01  -0.46475D-01   0.14495D-06   0.39739D-02  -0.74431D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.49128D-04   0.58662D-03   0.26884D-03   0.49566D-08  -0.12523D-02   0.23226D-02

MODE# 34/ 59, Frequency (rad/sec), Damping (zeta), Generalized Mass=    515.91       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.34259D-01   0.79832D-01  -0.14868D+00   0.64283D-02  -0.66716D-02  -0.37019D-03
S1 Engine No:2 +Y-Z               1152     0.48138D-01   0.78913D-01  -0.14599D+00  -0.76684D-02  -0.11376D-01   0.13518D-02
S1 Engine No:3 -Y-Z               1153     0.35570D-01   0.77153D-01  -0.14149D+00   0.50095D-02  -0.20299D-01  -0.12622D-01
S1 Engine No:4 -Y-Z               1154    -0.10506D-01   0.70852D-01  -0.14846D+00  -0.30233D-04  -0.13768D-01  -0.16711D-01
S1 Engine No:5 -Y+Z               1155    -0.33214D-01   0.80926D-01  -0.14935D+00  -0.64676D-02  -0.65472D-02  -0.71041D-04
S1 Engine No:6 -Y+Z               1156    -0.47466D-01   0.79706D-01  -0.14625D+00   0.82651D-02  -0.11242D-01   0.18683D-02
S1 Engine No:7 +Y+Z               1157    -0.36074D-01   0.77946D-01  -0.14027D+00  -0.44293D-02  -0.20645D-01  -0.11992D-01
S1 Engine No:8 +Y+Z               1158     0.10664D-01   0.70938D-01  -0.14765D+00  -0.10874D-02  -0.14536D-01  -0.17116D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01  -0.52292D-07  -0.10041D-02  -0.52972D-03
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01  -0.52292D-07  -0.10041D-02  -0.52972D-03
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01  -0.52292D-07  -0.10041D-02  -0.52972D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.83882D-03  -0.17814D-01   0.33784D-01   0.13307D-06   0.28526D-02   0.15035D-02
Fuel Slosh Mass Locat.             600     0.18757D-02   0.46258D-01  -0.87687D-01  -0.12178D-05   0.75188D-02   0.39570D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.27411D-04  -0.31296D-03   0.51136D-03   0.15654D-07  -0.23532D-02  -0.12262D-02
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
