BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Launch Vehicle Stage-1 Control Design at T=140 sec
! This batch set creates Pitch and Lateral State-Space models for a
! Classical Launch Vehicle and performs LQR Control Design
!
! --------------   LQR Matrices Qc,Rc for Pitch and Lateral
Retain Matrix    : Pitch State Weight Matrix Qc (4x4)                                                                         
Retain Matrix    : Pitch Control Weight Matrix Rc 
Retain Matrix    : Lateral State Weight Matrix Qc (6x6)                                                                        
Retain Matrix    : Lateral Control Weight Matrix Rc (2x2)                                                                      
!
! --------------   Create Vehicle Models
Flight Vehicle   : Launch Vehicle First Stage Design Model, T=140.0 sec
Mixing Matrix    : Vehicle Mixing Logic
Transf-Functions : Integrator 
System Connection: Vehicle Design Model with TVC
System Connection: Vehicle Analysis Model with TVC
!
! --------------   Pitch LQR Design on Augmented Model
System Modificat : Pitch Design Model  
System Connection: Augmented Pitch Design Model
LQR Control Des  : Pitch LQR Control Design
!
! --------------   Lateral LQR Design on Augmented Model
System Modificat : Lateral Design Model   
System Connection: Augmented Lateral Design Model  
LQR Control Des  : Lateral LQR Control Design
!
! --------------   Export Systems & TVC to Matlab
To Matlab Format : Vehicle Analysis Model with TVC            
To Matlab Format : Vehicle Mixing Logic 
To Matlab Format : Pitch LQR State-Feedback Controller
To Matlab Format : Lateral LQR State-Feedback Controller
To Matlab Format : Augmented Pitch Design Model
To Matlab Format : Augmented Lateral Design Model  
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Design Model, T=140.0 sec                                         
! This is the Launch Vehicle Control Design Model at t=140 sec
! includes 8 TVC Engines, No Slosh, No Bending   
!                                                                               
Body Axes Output, Attitude=Rate Integrals         
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   2137.92       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   16371.1      0.198735E+07  0.198639E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   65.3890       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   4.27400       4543.22       46.8400       145222.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   88.1929       105.950       0.0          -0.115100    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   1.06800       0.00          0.00000       0.0
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           35.22         0.00000       0.0          -0.3077        0.0
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.00         90.00                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.4150       7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.970986      0.00148     -0.578534E-04   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0          -0.077         0.00000       0.0           0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.0788       -0.077         0.00000       0.0           0.00000       0.00000     -0.174522E-06
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.151063     -0.17200       0.00000       0.0           0.00000     -0.147012E-04   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0           0.1700        0.00000       0.00000       0.00000      0.204000E-01

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   NO TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       2.49450      -1.03320    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       1.03320      -2.49450    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -1.03320      -2.49450    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -2.49450      -1.03320    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -2.49450       1.03320    
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -1.03320       2.49450    
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       1.03320       2.49450    
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       2.49450       1.03320    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000     
----------------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Vehicle Mixing Logic
! Generates the Thrust Vector Control Matrix for the Launch Vehicle at T=140 sec 
! This vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Design Model, T=140.0 sec 
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Integrator
Continuous
TF. Block #  1   (1/s)                                           Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         0.0
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  1  1    1.00000
...........................
Outpt #, from Block #, Gain
  1  1    1.00000
...........................
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Vehicle Design Model with TVC 
! Combines the Vehicle Model with the TVC Matrix
!
Titles of Systems to be Combined
Title 1 Launch Vehicle First Stage Design Model, T=140.0 sec
SYSTEM INPUTS TO SUBSYSTEM  1                                                                   TVC to Vehicle
Via Matrix +TVC                                                                                 roll, pitch, yaw
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                Vehicle Outputs
Via Matrix +I8                                                                                  First 8 Outputs
..............................................................................
Definitions of Inputs  =  3
Roll  TVC Demand from Flight Control
Pitch TVC Demand from Flight Control
Yaw   TVC Demand from Flight Control
 
Definitions of Outputs =  8
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (theta)  (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,  (radians)                                                             
Angle of sideslip, beta, (radian)                                                            

Definitions of States  = 10                                                                                       
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (theta)  (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,  (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude (delta-h) (feet)                                                     
Change in Velocity (delta-V) (ft/sec)                                                   
-------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Vehicle Analysis Model with TVC 
! Combines the Vehicle Model with the TVC Matrix
! It includes the Wind-Gust Input
!
Titles of Systems to be Combined
Title 1 Launch Vehicle First Stage Design Model, T=140.0 sec
SYSTEM INPUTS TO SUBSYSTEM  1                                                                   TVC to Vehicle
Via Matrix +TVC                                                                                 roll, pitch, yaw Demands
Via Matrix +I01                                                                                 Gust Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                Vehicle Outputs
Via Matrix +I8                                                                                  First 8 Vehi Outputs
..............................................................................
Definitions of Inputs  =  4
Roll  TVC Demand from Flight Control
Pitch TVC Demand from Flight Control
Yaw   TVC Demand from Flight Control
Wind-Gust Velocity in (ft/sec)
 
Definitions of Outputs =  8
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (theta)  (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,  (radians)                                                             
Angle of sideslip, beta, (radian)                                                            

Definitions of States  = 10                                                                                       
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (theta)  (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,  (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude (delta-h) (feet)                                                     
Change in Velocity (delta-V) (ft/sec)                                                   
------------------------------------------------------------------------------------------------------------------------
                                PITCH DESIGN
------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Pitch Design Model                                          
Vehicle Design Model with TVC                                                        
! The 3-state pitch rigid body system is extracted from the coupled RB Design 
! system above  
!                                   
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2
Extract States :   3   4   7
Extract Outputs:   3   4   7
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Augmented Pitch Design Model
! Create a 4-State Augmented Pitch Model that Includes Theta-Integral
!
Titles of Systems to be Combined   
Title 1 Pitch Design Model 
Title 2 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                          Pitch 3-State Design Model
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                   Delta Command
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                       Vehicle Plant
System Output  1 from Subsystem  1, Output  1, Gain= 1.0                               theta
System Output  2 from Subsystem  1, Output  2, Gain= 1.0                               q - pitch rate
System Output  3 from Subsystem  1, Output  3, Gain= 1.0                               alpha
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                       Integrator
System Output  4 from Subsystem  2, Output  1, Gain= 1.0                               theta-integral
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                Plant to Integrator
Subsystem  1, Output  1 to Subsystem  2, Input  1, Gain=   1.0000                      theta
......................................................................
Definitions of Inputs  =   1
Pitch TVC Command (DQ_tvc)

Definitions of Outputs =   4
Pitch Attitude, theta  (rad)
Pitch Rate, q (rad/sec)
Angle of Attack, alpha (rad)
Theta-Integral (rad-sec)

Definitions of States  =   4
Pitch Attitude, theta  (rad)
Pitch Rate, q (rad/sec)
Angle of Attack, alpha (rad)
Theta-Integral (rad-sec)
-------------------------------------------------------------------------------
LINEAR QUADRATIC REGULATOR STATE-FEEDBACK CONTROL DESIGN                                                                                                                                                
Pitch LQR Control Design                                                                                                                      
Plant Model Used to Design the Control System from:        Augmented Pitch Design Model                                                                                                      
Criteria Optimization Output is Matrix C                                                                                                                                                                
State Penalty Weight (Qc) is Matrix:   Qc4                 Pitch State Weight Matrix Qc (4x4)                                                                                                                 
Control Penalty Weight (Rc) is Matrix: Rc                  Pitch Control Weight Matrix Rc                                                                                                                     
Continuous LQR Solution Using Laub Method                                                                                                                                                               
LQR State-Feedback Control Gain Matrix Kq_t140             Pitch LQR State-Feedback Controller                                                                                     
------------------------------------------------------------------------------------------------------------------------
                                LATERAL DESIGN
------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Lateral Design Model                                          
Vehicle Design Model with TVC                                                              
! The 5-state lateral rigid body system is extracted from the coupled 
! RB design system above   
!                                  
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   3
Extract States :   1   2   5   6   8
Extract Outputs:   1   2   5   6   8
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Augmented Lateral Design Model
! Create a 6-State Augmented Lateral Model that Includes Psi-Integral
!
Titles of Systems to be Combined   
Title 1 Lateral Design Model 
Title 2 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                          Lateral Design Model
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                   Roll TVC Demand
System Input  2 to Subsystem  1, Input  2, Gain= 1.0                                   Yaw  TVC Demand
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                       Vehicle Plant
System Output  1 from Subsystem  1, Output  1, Gain= 1.0                               Roll Attitude  (phi)    
System Output  2 from Subsystem  1, Output  2, Gain= 1.0                               Roll Rate      (p-body) 
System Output  3 from Subsystem  1, Output  3, Gain= 1.0                               Yaw  Attitude  (psi)    
System Output  4 from Subsystem  1, Output  4, Gain= 1.0                               Yaw  Rate      (r-body) 
System Output  5 from Subsystem  1, Output  5, Gain= 1.0                               Angle of sideslip, beta
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                       Integrator
System Output  6 from Subsystem  2, Output  1, Gain= 1.0                               Psi-integral
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                Plant to Integrator
Subsystem  1, Output  3 to Subsystem  2, Input  1, Gain=   1.0000                      Psi
......................................................................
Definitions of Inputs  =   2
Roll TVC Command (DP_tvc)
Yaw  TVC Command (DR_tvc)

Definitions of Outputs =   6
Roll Attitude  (phi)    (radians)                                               
Roll Rate      (p-body) (rad/sec)                                               
Yaw  Attitude  (psi)    (radians)                                               
Yaw  Rate      (r-body) (rad/sec)                                               
Angle of sideslip, beta, (radian)    
Yaw, Psi-Integral       (rad-sec)                                    

Definitions of States  =   6
Roll Attitude  (phi)    (radians)                                               
Roll Rate      (p-body) (rad/sec)                                               
Yaw  Attitude  (psi)    (radians)                                               
Yaw  Rate      (r-body) (rad/sec)                                               
Angle of sideslip, beta, (radian)    
Yaw, Psi-Integral       (rad-sec)                                    
------------------------------------------------------------------------------------------------------------------------
LINEAR QUADRATIC REGULATOR STATE-FEEDBACK CONTROL DESIGN                                                                                                                                                
Lateral LQR Control Design                                                                                                                         
Plant Model Used to Design the Control System from:        Augmented Lateral Design Model                                                                                                          
Criteria Optimization Output is Matrix C                                                                                                                                                                
State Penalty Weight (Qc) is Matrix:   Qc6                 Lateral State Weight Matrix Qc (6x6)                                                                                                                
Control Penalty Weight (Rc) is Matrix: Rc2                 Lateral Control Weight Matrix Rc (2x2)                                                                                                                    
Continuous LQR Solution Using Laub Method                                                                                                                                                               
LQR State-Feedback Control Gain Matrix Kpr_t140            Lateral LQR State-Feedback Controller                                                                          
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Vehicle Analysis Model with TVC
System
plant_t140.m
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Design Model
System
pitch_rb_t140.m
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lateral Design Model
System
later_rb_t140.m
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Vehicle Mixing Logic
Matrix TVC
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch LQR State-Feedback Controller
Matrix Kq_t140
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lateral LQR State-Feedback Controller
Matrix Kpr_t140
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Augmented Pitch Design Model
System
pitch_des.m
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Augmented Lateral Design Model
System
later_des.m
----------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
