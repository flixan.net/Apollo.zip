BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Calculating the Vehicle files during Stage-2
! This batch set creates state-space systems for the Launch Vehicle during second stage
! and the Mixing Logic Matrix. Then it extracts the longitudinal and lateral subsystems,  
! adds attitude trim integrators, and performs LQR control design. 
! 
!                  Keep the Previous LQR Design Matrices
Retain Matrix    : Pitch State Weight Matrix Qc (3x3)                                                        
Retain Matrix    : Pitch Control Weight Matrix Rc 
Retain Matrix    : Lateral State Weight Matrix Qc (5x5)                  
Retain Matrix    : Lateral Control Weight Matrix Rc (2x2) 
!
!                  Create the Vehicle and the Mixing Logic Matrix
Flight Vehicle   : Launch Vehicle Second Stage Design Model at T=280 sec
Mixing Matrix    : Mixing Logic Matrix for Second Stage at t=280 sec
System Connection: Vehicle and Mixing Logic Combined System 
Transf-Functions : Integrator 
!
!                  Perform Pitch LQR Design
System Modificat : Stage-2 Pitch Design Model 
System Connection: Augmented Pitch Design Model
LQR Control Des  : Pitch LQR Control Design
!
!                  Perform Lateral LQR Design
System Modificat : Stage-2 Lateral Design Model 
System Connection: Augmented Lateral Design Model  
LQR Control Des  : Lateral LQR Control Design
!
!                  Convert Data to Matlab Format
To Matlab Format : Launch Vehicle Second Stage Design Model at T=280 sec 
To Matlab Format : Mixing Logic Matrix for Second Stage at t=280 sec
To Matlab Format : Augmented Pitch Design Model
To Matlab Format : Augmented Lateral Design Model 
To Matlab Format : Pitch LQR State-Feedback Controller
To Matlab Format : Lateral LQR State-Feedback Controller
-----------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle Second Stage Design Model at T=280 sec
! This dataset creates the Design Vehicle Model during Second Stage, consisting of 
! the main engine and four bi-directional RCS jets.
!                                                                              
Body Axes Output, Attitude=Rate Integral
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   718.374       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   4790.87       22960.4       22801.4       0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   91.8984       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   5.74000       10248.9      0.100000E-04   512293.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   36.2100       41.4153     -0.950000E-02  0.174000E-01
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   6.42100      -3.75900      0.300052E-01  0.100024    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          15.8070       0.00000       0.000        -0.108000     -0.0896
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.00000      90.00000                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   38.5000       7.20000       7.20000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   116.800       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.450125      0.149995E-03 -0.514195E-05   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.127243     -0.353150E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.290584     -0.632500E-01   0.00000       0.00000       0.00000       0.00000      0.939033E-06
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.429066     -0.117700       0.00000       0.00000       0.00000     -0.118214E-05   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0           0.039805       0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   NO TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Main Engine      Gimbaling 
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   29752.0       29752.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   9.00000       120.000       2.60000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   84.5000       0.00000       0.00000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00        -3.50          0.00000    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Rght RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0   
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         3.50          0.00000    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Top  RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000      -3.50    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Botm RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000       3.50    
----------------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Matrix for Second Stage at t=280 sec
! Mixing Logic Matrix for the Launch Vehicle during Second Stage.
! It Combines the TVC Engine with the 4 RCS Jets
!
Kmix
Launch Vehicle Second Stage Design Model at T=280 sec
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Vehicle and Mixing Logic Combined System 
! Combine the Vehicle System with Kmix in front to be used in the LQR design 
!
Titles of Systems to be Combined  
Title 1 Launch Vehicle Second Stage Design Model at T=280 sec
SYSTEM INPUTS TO SUBSYSTEM  1
Via Matrix +Kmix                                                                The (6x3) Mixing Logic Matrix
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                
Via Matrix +I8
..............................................................................
Definitions of Inputs  =   3
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
 
Definitions of Outputs =   8
Roll Attitude  (phi-body) (radians)                                                          
Roll Rate      (p-body)   (rad/sec)                                                          
Ptch Attitude  (theta-body) (radians)                                                   
Ptch Rate      (q-body)   (rad/sec)                                                   
Yaw  Attitude  (psi-body) (radians)                                                          
Yaw  Rate      (r-body)   (rad/sec)                                                          
Angle of Attack,  alpha, (radians)                                                            
Angle of Sideslip, beta, (radians)                                                   
--------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Integrator
Continuous
TF. Block #  1  (1/s)                                            Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         0.0
---------------------------------------------------------------------------------------------
Block #, from Input #, Gain
  1  1    1.00000
...........................
Outpt #, from Block #, Gain
  1  1    1.00000
...........................
----------------------------------------------------------------------------------------------------------------------------
                                PITCH DESIGN
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Stage-2 Pitch Design Model 
Vehicle and Mixing Logic Combined System 
! The Pitch rigid system is Extracted from the Coupled rigid system above  
!                                    
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2
Extract States :   3   4   
Extract Outputs:   3   4   
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Augmented Pitch Design Model
! Create a 4-State Augmented Pitch Model that Includes Theta-Integral
!
Titles of Systems to be Combined   
Title 1 Stage-2 Pitch Design Model 
Title 2 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                          Pitch Design
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                   Delta Command
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                       Vehicle Plant
System Output  1 from Subsystem  1, Output  1, Gain= 1.0                               theta
System Output  2 from Subsystem  1, Output  2, Gain= 1.0                               q - pitch rate
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                       Integrator
System Output  3 from Subsystem  2, Output  1, Gain= 1.0                               theta-integral
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                Plant to Integrator
Subsystem  1, Output  1 to Subsystem  2, Input  1, Gain=   1.0000                      theta          
......................................................................
Definitions of Inputs  =   1
Pitch TVC Command (DQ_tvc)

Definitions of Outputs =   3
Pitch Attitude, theta  (rad)
Pitch Rate, q (rad/sec)
Theta-Integral (rad-sec)

Definitions of States  =   3
Pitch Attitude, theta  (rad)
Pitch Rate, q (rad/sec)
Theta-Integral (rad-sec)
--------------------------------------------------------------------------------------------------------------------------
LINEAR QUADRATIC REGULATOR STATE-FEEDBACK CONTROL DESIGN                                                                                                                                                
Pitch LQR Control Design                                                                                                                      
Plant Model Used to Design the Control System from:        Augmented Pitch Design Model                                                                                                      
Criteria Optimization Output is Matrix C                                                                                                                                                                
State Penalty Weight (Qc) is Matrix:   Qc3                 Pitch State Weight Matrix Qc (3x3)                                                                                                                 
Control Penalty Weight (Rc) is Matrix: Rc                  Pitch Control Weight Matrix Rc                                                                                                                     
Continuous LQR Solution Using Laub Method                                                                                                                                                               
LQR State-Feedback Control Gain Matrix Kq_t280             Pitch LQR State-Feedback Controller                                                                                     
---------------------------------------------------------------------------------------------------------------------------
                                LATERAL DESIGN
---------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Stage-2 Lateral Design Model 
Vehicle and Mixing Logic Combined System 
! The Lateral rigid body system is Extracted from the Coupled RB system above  
!                                   
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   3
Extract States :   1   2   5   6   
Extract Outputs:   1   2   5   6  
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Augmented Lateral Design Model
! Create a 5-State Augmented Lateral Model that Includes Psi-Integral
!
Titles of Systems to be Combined   
Title 1 Stage-2 Lateral Design Model 
Title 2 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                          Lateral Design Model
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                   Roll TVC Demand
System Input  2 to Subsystem  1, Input  2, Gain= 1.0                                   Yaw  TVC Demand
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                       Vehicle Plant
System Output  1 from Subsystem  1, Output  1, Gain= 1.0                               Roll Attitude  (phi)    
System Output  2 from Subsystem  1, Output  2, Gain= 1.0                               Roll Rate      (p-body) 
System Output  3 from Subsystem  1, Output  3, Gain= 1.0                               Yaw  Attitude  (psi)    
System Output  4 from Subsystem  1, Output  4, Gain= 1.0                               Yaw  Rate      (r-body) 
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                       Integrator
System Output  5 from Subsystem  2, Output  1, Gain= 1.0                               Psi-integral
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                Plant to Integrator
Subsystem  1, Output  3 to Subsystem  2, Input  1, Gain=   1.0000                      Psi
......................................................................
Definitions of Inputs  =   2
Roll TVC Command (DP_tvc)
Yaw  TVC Command (DR_tvc)

Definitions of Outputs =   5
Roll Attitude  (phi)    (radians)                                               
Roll Rate      (p-body) (rad/sec)                                               
Yaw  Attitude  (psi)    (radians)                                               
Yaw  Rate      (r-body) (rad/sec)                                               
Yaw, Psi-Integral       (rad-sec)                                    

Definitions of States  =   5
Roll Attitude  (phi)    (radians)                                               
Roll Rate      (p-body) (rad/sec)                                               
Yaw  Attitude  (psi)    (radians)                                               
Yaw  Rate      (r-body) (rad/sec)                                               
Yaw, Psi-Integral       (rad-sec)                                    
----------------------------------------------------------------------------------------------------------------------------
LINEAR QUADRATIC REGULATOR STATE-FEEDBACK CONTROL DESIGN                                                                                                                                                
Lateral LQR Control Design                                                                                                                         
Plant Model Used to Design the Control System from:        Augmented Lateral Design Model                                                                                                          
Criteria Optimization Output is Matrix C                                                                                                                                                                
State Penalty Weight (Qc) is Matrix:   Qc5                 Lateral State Weight Matrix Qc (5x5)                                                                                                                
Control Penalty Weight (Rc) is Matrix: Rc2                 Lateral Control Weight Matrix Rc (2x2)                                                                                                                    
Continuous LQR Solution Using Laub Method                                                                                                                                                               
LQR State-Feedback Control Gain Matrix Kpr_t280            Lateral LQR State-Feedback Controller                                                                          
----------------------------------------------------------------------------------------------------------------------------
                                  CREATE MATLAB DATA
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle Second Stage Design Model at T=280 sec 
System
Vehicle_rb
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Matrix for Second Stage at t=280 sec
Matrix Kmix
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Augmented Pitch Design Model
System
pitch_des.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Augmented Lateral Design Model
System
lateral_des.m
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch LQR State-Feedback Controller
Matrix Kq_t280
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lateral LQR State-Feedback Controller
Matrix Kpr_t280
----------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
