BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Launch Vehicle systems during Second Stage
! This batch set creates state-space systems for the Flexible Launch Vehicle during 
! Second Stage, the Mixing Logic matrix and also the 2nd Stage Actuator. 
! 
Flight Vehicle   : Launch Vehicle Second Stage Analysis Model at T=350 sec         
Actuator Model   : Stage-2 Linear Actuator
Mixing Matrix    : Mixing Logic Matrix for Second Stage Vehicle at t=350 sec
!
To Matlab Format : Launch Vehicle Second Stage Analysis Model at T=350 sec          
To Matlab Format : Stage-2 Linear Actuator
To Matlab Format : Mixing Logic Matrix for Second Stage Vehicle at t=350 sec
-----------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle Second Stage Analysis Model at T=350 sec
! This is the Analysis Model of Second Stage Vehicle consisting of the main engine
! and four bi-directional RCS jets. It includes Slosh and Flexibility
!
Body Axes Output, Attitude=Rate Integral             
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   542.967       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   3560.84       20921.5       20762.6       0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   91.7520       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   6.92200       13335.8      0.100000E-04   592358.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   52.9133       54.7947     -0.840000E-02 -0.810000E-02
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   6.81600     -0.760000E-01 -0.600103E-01  0.200048E-01
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          9.850         0.00000       0.0          -0.168100     -0.227000E-01
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.00000      90.00000                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   38.5000       7.20000       7.20000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   116.800       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.435938      0.400007E-03 -0.385451E-05   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.214269E-02 -0.281933E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.311294     -0.573000E-01   0.00000       0.00000       0.00000       0.00000      0.153303E-05
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.465297     -0.101250       0.00000       0.00000       0.00000      0.496112E-05   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}: -0.151569E-02  0.199433E-01   0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Main Engine#1    Gimbaling 
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   29751.7       29751.7    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   9.00000       120.000       2.60000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   84.5000       0.00000       0.00000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00        -3.50          0.00000    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Rght RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0   
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         3.50          0.00000    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Top  RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000      -3.50    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Botm RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000       3.50    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438     0.00       0.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438     0.00       0.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438     0.00       0.00    

Number of Slosh Modes                                                                    :  2
LOX  Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :  119.25  3.12  3.12  0.002 0.002  93.363  0.0  0.0   
Fuel Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :  41.120  3.12  3.12  0.002 0.002  86.476  0.0  0.0  

Number of Bending Modes                                                                  :  10
Flex Modes of Vehicle Second Stage with Slosh, 40% Full Tanks
----------------------------------------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-2 Linear Actuator        
Symbol Parameter Description                    (Units)      Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.002, 0.002
Ka     Gain of Amplifier ...................... (amps/volt)   10.0    
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    60.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.0e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     1.8e+6
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.72   
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   120.0
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   3000.0    
----------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Matrix for Second Stage Vehicle at t=350 sec
! Mixing Logic Matrix for the Second Stage Vehicle
!
Kmix_t350
Launch Vehicle Second Stage Analysis Model at T=350 sec
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
                                  CREATE MATLAB DATA
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle Second Stage Analysis Model at T=350 sec 
System
Vehicle
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-2 Linear Actuator     
System
actuator
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Matrix for Second Stage Vehicle at t=350 sec
Matrix Kmix_t350
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : Stage-2 40% Full
Flex Modes of Vehicle Second Stage with Slosh, 40% Full Tanks
! Flex Modes for Second Stage with Empty Tanks, from File: Stage2_40%.Mod
! Sensors are at the Top of LOX Tank at Node: 604
! The Modes were selected between the TVC (Node:10408) and the IMU Locat. (Node:604)

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    57.917       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.12304D-01   0.59391D-01   0.67126D-01  -0.84510D-04   0.10018D+00  -0.97450D-01
Stage-2 Gimbal                   10408     0.12304D-01   0.59391D-01   0.67126D-01  -0.84510D-04   0.10018D+00  -0.97450D-01
Stage-2 Gimbal                   10408     0.12304D-01   0.59391D-01   0.67126D-01  -0.84510D-04   0.10018D+00  -0.97450D-01
Stage-2 Gimbal                   10408     0.12304D-01   0.59391D-01   0.67126D-01  -0.84510D-04   0.10018D+00  -0.97450D-01
Stage-2 Gimbal                   10408     0.12304D-01   0.59391D-01   0.67126D-01  -0.84510D-04   0.10018D+00  -0.97450D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.14307D-02  -0.15589D-01  -0.16979D-01  -0.35326D-05  -0.42727D-02   0.39275D-02
Stage-2 Tank Top, IMU Location     604    -0.14307D-02  -0.15589D-01  -0.16979D-01  -0.35326D-05  -0.42727D-02   0.39275D-02
Stage-2 Tank Top, IMU Location     604    -0.14307D-02  -0.15589D-01  -0.16979D-01  -0.35326D-05  -0.42727D-02   0.39275D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     601    -0.14294D-02  -0.19873D-01  -0.21640D-01  -0.35306D-05  -0.41845D-02   0.38464D-02
LH2 Slosh Mass Locat.              600    -0.14083D-02  -0.39077D-01  -0.42530D-01  -0.34765D-05  -0.37042D-02   0.34045D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.14443D-02   0.11991D+00   0.13040D+00  -0.36401D-05  -0.96822D-02   0.89021D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    64.146       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.31167D-03   0.94451D-01  -0.91420D-01  -0.93679D-02  -0.11788D+00  -0.12767D+00
Stage-2 Gimbal                   10408    -0.31167D-03   0.94451D-01  -0.91420D-01  -0.93679D-02  -0.11788D+00  -0.12767D+00
Stage-2 Gimbal                   10408    -0.31167D-03   0.94451D-01  -0.91420D-01  -0.93679D-02  -0.11788D+00  -0.12767D+00
Stage-2 Gimbal                   10408    -0.31167D-03   0.94451D-01  -0.91420D-01  -0.93679D-02  -0.11788D+00  -0.12767D+00
Stage-2 Gimbal                   10408    -0.31167D-03   0.94451D-01  -0.91420D-01  -0.93679D-02  -0.11788D+00  -0.12767D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.74967D-04  -0.19390D-01   0.17957D-01   0.20378D-04   0.36276D-02   0.39238D-02
Stage-2 Tank Top, IMU Location     604    -0.74967D-04  -0.19390D-01   0.17957D-01   0.20378D-04   0.36276D-02   0.39238D-02
Stage-2 Tank Top, IMU Location     604    -0.74967D-04  -0.19390D-01   0.17957D-01   0.20378D-04   0.36276D-02   0.39238D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     601    -0.74885D-04  -0.23720D-01   0.21960D-01   0.20364D-04   0.35233D-02   0.38108D-02
LH2 Slosh Mass Locat.              600    -0.73525D-04  -0.42090D-01   0.38942D-01   0.19981D-04   0.29626D-02   0.32035D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.75845D-04   0.14101D+00  -0.13027D+00   0.21144D-04   0.10132D-01   0.10965D-01

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    142.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.44361D-03  -0.65753D-02  -0.54999D-02  -0.96997D+00   0.90851D-02  -0.60847D-03
Stage-2 Gimbal                   10408     0.44361D-03  -0.65753D-02  -0.54999D-02  -0.96997D+00   0.90851D-02  -0.60847D-03
Stage-2 Gimbal                   10408     0.44361D-03  -0.65753D-02  -0.54999D-02  -0.96997D+00   0.90851D-02  -0.60847D-03
Stage-2 Gimbal                   10408     0.44361D-03  -0.65753D-02  -0.54999D-02  -0.96997D+00   0.90851D-02  -0.60847D-03
Stage-2 Gimbal                   10408     0.44361D-03  -0.65753D-02  -0.54999D-02  -0.96997D+00   0.90851D-02  -0.60847D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.33833D-04   0.23848D-02   0.82141D-03   0.50690D-02  -0.12023D-03   0.50639D-03
Stage-2 Tank Top, IMU Location     604    -0.33833D-04   0.23848D-02   0.82141D-03   0.50690D-02  -0.12023D-03   0.50639D-03
Stage-2 Tank Top, IMU Location     604    -0.33833D-04   0.23848D-02   0.82141D-03   0.50690D-02  -0.12023D-03   0.50639D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.33646D-04   0.18517D-02   0.69307D-03   0.50507D-02  -0.12589D-03   0.52868D-03
Fuel Slosh Mass Locat.             600    -0.30606D-04  -0.15795D-02  -0.20581D-03   0.45722D-02  -0.14100D-03   0.60790D-03

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.35873D-04  -0.11629D-01  -0.31338D-02   0.61712D-02   0.41916D-03  -0.15306D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    149.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.13709D-01   0.15373D+00   0.16697D+00  -0.16364D-01  -0.70367D-02   0.12083D-01
Stage-2 Gimbal                   10408    -0.13709D-01   0.15373D+00   0.16697D+00  -0.16364D-01  -0.70367D-02   0.12083D-01
Stage-2 Gimbal                   10408    -0.13709D-01   0.15373D+00   0.16697D+00  -0.16364D-01  -0.70367D-02   0.12083D-01
Stage-2 Gimbal                   10408    -0.13709D-01   0.15373D+00   0.16697D+00  -0.16364D-01  -0.70367D-02   0.12083D-01
Stage-2 Gimbal                   10408    -0.13709D-01   0.15373D+00   0.16697D+00  -0.16364D-01  -0.70367D-02   0.12083D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.11051D-02  -0.94094D-01  -0.10084D+00   0.67963D-04   0.22901D-01  -0.21372D-01
Stage-2 Tank Top, IMU Location     604     0.11051D-02  -0.94094D-01  -0.10084D+00   0.67963D-04   0.22901D-01  -0.21372D-01
Stage-2 Tank Top, IMU Location     604     0.11051D-02  -0.94094D-01  -0.10084D+00   0.67963D-04   0.22901D-01  -0.21372D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.10983D-02  -0.71279D-01  -0.76398D-01   0.67686D-04   0.23792D-01  -0.22205D-01
Fuel Slosh Mass Locat.             600     0.98859D-03   0.72289D-01   0.77444D-01   0.60586D-04   0.26575D-01  -0.24802D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.11791D-02   0.43825D+00   0.46962D+00   0.84662D-04  -0.64330D-01   0.60032D-01

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    151.11       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.14999D-03   0.14241D+00  -0.13367D+00  -0.55019D-02   0.29458D-01   0.32122D-01
Stage-2 Gimbal                   10408     0.14999D-03   0.14241D+00  -0.13367D+00  -0.55019D-02   0.29458D-01   0.32122D-01
Stage-2 Gimbal                   10408     0.14999D-03   0.14241D+00  -0.13367D+00  -0.55019D-02   0.29458D-01   0.32122D-01
Stage-2 Gimbal                   10408     0.14999D-03   0.14241D+00  -0.13367D+00  -0.55019D-02   0.29458D-01   0.32122D-01
Stage-2 Gimbal                   10408     0.14999D-03   0.14241D+00  -0.13367D+00  -0.55019D-02   0.29458D-01   0.32122D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.21108D-04  -0.10069D+00   0.93919D-01   0.14027D-03  -0.21736D-01  -0.23305D-01
Stage-2 Tank Top, IMU Location     604     0.21108D-04  -0.10069D+00   0.93919D-01   0.14027D-03  -0.21736D-01  -0.23305D-01
Stage-2 Tank Top, IMU Location     604     0.21108D-04  -0.10069D+00   0.93919D-01   0.14027D-03  -0.21736D-01  -0.23305D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.20975D-04  -0.75763D-01   0.70668D-01   0.13968D-03  -0.22564D-01  -0.24193D-01
Fuel Slosh Mass Locat.             600     0.18844D-04   0.80288D-01  -0.74876D-01   0.12476D-03  -0.25096D-01  -0.26908D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.22546D-04   0.46824D+00  -0.43672D+00   0.17546D-03   0.60210D-01   0.64556D-01

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    257.64       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.67398D+00   0.65699D-01   0.75094D-01  -0.90899D-03   0.70578D-01  -0.52942D-01
Stage-2 Gimbal                   10408    -0.67398D+00   0.65699D-01   0.75094D-01  -0.90899D-03   0.70578D-01  -0.52942D-01
Stage-2 Gimbal                   10408    -0.67398D+00   0.65699D-01   0.75094D-01  -0.90899D-03   0.70578D-01  -0.52942D-01
Stage-2 Gimbal                   10408    -0.67398D+00   0.65699D-01   0.75094D-01  -0.90899D-03   0.70578D-01  -0.52942D-01
Stage-2 Gimbal                   10408    -0.67398D+00   0.65699D-01   0.75094D-01  -0.90899D-03   0.70578D-01  -0.52942D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.43087D-01   0.30721D-02   0.33346D-02   0.38382D-05  -0.19604D-02   0.18109D-02
Stage-2 Tank Top, IMU Location     604     0.43087D-01   0.30721D-02   0.33346D-02   0.38382D-05  -0.19604D-02   0.18109D-02
Stage-2 Tank Top, IMU Location     604     0.43087D-01   0.30721D-02   0.33346D-02   0.38382D-05  -0.19604D-02   0.18109D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.42224D-01   0.77970D-03   0.85252D-03   0.37634D-05  -0.19427D-02   0.17946D-02
Fuel Slosh Mass Locat.             600     0.29455D-01  -0.86137D-02  -0.93247D-02   0.24626D-05  -0.15745D-02   0.14552D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.52698D-01  -0.19180D-01  -0.20774D-01   0.91511D-05   0.41520D-02  -0.38334D-02

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    347.01       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.52188D-04   0.19526D-03   0.33627D-03   0.44528D-02  -0.33850D-04   0.13757D-04
Stage-2 Gimbal                   10408     0.52188D-04   0.19526D-03   0.33627D-03   0.44528D-02  -0.33850D-04   0.13757D-04
Stage-2 Gimbal                   10408     0.52188D-04   0.19526D-03   0.33627D-03   0.44528D-02  -0.33850D-04   0.13757D-04
Stage-2 Gimbal                   10408     0.52188D-04   0.19526D-03   0.33627D-03   0.44528D-02  -0.33850D-04   0.13757D-04
Stage-2 Gimbal                   10408     0.52188D-04   0.19526D-03   0.33627D-03   0.44528D-02  -0.33850D-04   0.13757D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.29213D-05   0.21155D-04  -0.17435D-04  -0.12210D-01   0.30672D-04   0.35657D-04
Stage-2 Tank Top, IMU Location     604    -0.29213D-05   0.21155D-04  -0.17435D-04  -0.12210D-01   0.30672D-04   0.35657D-04
Stage-2 Tank Top, IMU Location     604    -0.29213D-05   0.21155D-04  -0.17435D-04  -0.12210D-01   0.30672D-04   0.35657D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.27996D-05  -0.35581D-04   0.31283D-04  -0.15185D-01   0.28438D-04   0.33046D-04
Fuel Slosh Mass Locat.             600    -0.12003D-05  -0.11110D-03   0.95114D-04  -0.22211D-01   0.12874D-04   0.14756D-04

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.43210D-05  -0.46424D-03   0.39794D-03   0.25852D+00  -0.93436D-04  -0.10902D-03

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    374.27       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.92868D-01   0.36213D+00   0.58669D+00  -0.49716D-02   0.28385D+00  -0.16229D+00
Stage-2 Gimbal                   10408     0.92868D-01   0.36213D+00   0.58669D+00  -0.49716D-02   0.28385D+00  -0.16229D+00
Stage-2 Gimbal                   10408     0.92868D-01   0.36213D+00   0.58669D+00  -0.49716D-02   0.28385D+00  -0.16229D+00
Stage-2 Gimbal                   10408     0.92868D-01   0.36213D+00   0.58669D+00  -0.49716D-02   0.28385D+00  -0.16229D+00
Stage-2 Gimbal                   10408     0.92868D-01   0.36213D+00   0.58669D+00  -0.49716D-02   0.28385D+00  -0.16229D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.51353D-02   0.28499D-02   0.39654D-02   0.10656D-04  -0.15943D-01   0.10322D-01
Stage-2 Tank Top, IMU Location     604    -0.51353D-02   0.28499D-02   0.39654D-02   0.10656D-04  -0.15943D-01   0.10322D-01
Stage-2 Tank Top, IMU Location     604    -0.51353D-02   0.28499D-02   0.39654D-02   0.10656D-04  -0.15943D-01   0.10322D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.48717D-02  -0.15718D-01  -0.24646D-01   0.11248D-04  -0.14132D-01   0.91427D-02
Fuel Slosh Mass Locat.             600    -0.15716D-02  -0.20058D-01  -0.30658D-01   0.80726D-05  -0.29592D-02   0.18295D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.82023D-02  -0.16349D+00  -0.25148D+00  -0.49397D-04   0.61222D-01  -0.39806D-01

MODE#  9/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    458.64       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.36801D-01   0.14410D+00   0.25376D+00  -0.14821D-02   0.25177D+00  -0.14004D+00
Stage-2 Gimbal                   10408     0.36801D-01   0.14410D+00   0.25376D+00  -0.14821D-02   0.25177D+00  -0.14004D+00
Stage-2 Gimbal                   10408     0.36801D-01   0.14410D+00   0.25376D+00  -0.14821D-02   0.25177D+00  -0.14004D+00
Stage-2 Gimbal                   10408     0.36801D-01   0.14410D+00   0.25376D+00  -0.14821D-02   0.25177D+00  -0.14004D+00
Stage-2 Gimbal                   10408     0.36801D-01   0.14410D+00   0.25376D+00  -0.14821D-02   0.25177D+00  -0.14004D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.19748D-02   0.21007D-01   0.34460D-01   0.59293D-04   0.57744D-02  -0.35214D-02
Stage-2 Tank Top, IMU Location     604    -0.19748D-02   0.21007D-01   0.34460D-01   0.59293D-04   0.57744D-02  -0.35214D-02
Stage-2 Tank Top, IMU Location     604    -0.19748D-02   0.21007D-01   0.34460D-01   0.59293D-04   0.57744D-02  -0.35214D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.17791D-02   0.38091D-01   0.62688D-01   0.60061D-04   0.13127D-02  -0.82608D-03
Fuel Slosh Mass Locat.             600     0.22214D-03  -0.69372D-01  -0.11432D+00   0.16266D-04  -0.16240D-01   0.97393D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.43511D-02   0.24121D+00   0.39905D+00  -0.73008D-04  -0.10604D+00   0.64093D-01

MODE# 10/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    487.81       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.14438D-01  -0.37329D+00   0.23636D+00  -0.15233D-02   0.98588D-01   0.23118D+00
Stage-2 Gimbal                   10408    -0.14438D-01  -0.37329D+00   0.23636D+00  -0.15233D-02   0.98588D-01   0.23118D+00
Stage-2 Gimbal                   10408    -0.14438D-01  -0.37329D+00   0.23636D+00  -0.15233D-02   0.98588D-01   0.23118D+00
Stage-2 Gimbal                   10408    -0.14438D-01  -0.37329D+00   0.23636D+00  -0.15233D-02   0.98588D-01   0.23118D+00
Stage-2 Gimbal                   10408    -0.14438D-01  -0.37329D+00   0.23636D+00  -0.15233D-02   0.98588D-01   0.23118D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.75063D-03  -0.34511D-01   0.20293D-01   0.85932D-04  -0.60481D-03  -0.92448D-03
Stage-2 Tank Top, IMU Location     604     0.75063D-03  -0.34511D-01   0.20293D-01   0.85932D-04  -0.60481D-03  -0.92448D-03
Stage-2 Tank Top, IMU Location     604     0.75063D-03  -0.34511D-01   0.20293D-01   0.85932D-04  -0.60481D-03  -0.92448D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.65516D-03  -0.49217D-01   0.29031D-01   0.86640D-04  -0.26806D-02  -0.43991D-02
Fuel Slosh Mass Locat.             600    -0.23199D-03   0.12039D+00  -0.71265D-01   0.12821D-04  -0.93349D-02  -0.15418D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.19301D-02  -0.28882D+00   0.17231D+00  -0.82309D-04  -0.46930D-01  -0.78656D-01
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
