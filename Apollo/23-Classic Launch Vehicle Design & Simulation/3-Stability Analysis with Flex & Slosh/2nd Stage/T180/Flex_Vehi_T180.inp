BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Launch Vehicle systems during Second Stage
! This batch set creates state-space systems for the Flexible Launch Vehicle during 
! Second Stage and also for the 2nd Stage Actuator. 
! 
Flight Vehicle   : Launch Vehicle Second Stage Analysis Model, T=180 sec         
Actuator Model   : Stage-2 Linear Actuator
!
To Matlab Format : Launch Vehicle Second Stage Analysis Model, T=180 sec         
To Matlab Format : Stage-2 Linear Actuator
-----------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle Second Stage Analysis Model, T=180 sec
! This Model is for the Launch Vehicle's Second Stage consisting of the Main Engine
! and four bi-directional RCS jets. It includes Slosh and Structural Flexibility
!
Body Axes Output, Attitude=Rate Integral             
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   1040.75       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   8052.60       41988.1       41808.7       0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   93.3240       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   8.16600       7642.13      0.730000       269948.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   15.3018       28.5736     -0.136000E-01 -0.900000E-03
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0000        0.0           0.0           0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.000         25.5860       0.00000      -0.0          -0.436000     -0.680100    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.00000      90.00000                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   38.5000       7.20000       7.20000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   116.800       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.4251        0.00000     -0.141175E-04   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  -0.091747     -0.036         0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.0067816    -0.036         0.00000       0.00000       0.00000       0.00000     -0.269284E-07
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.004773     -0.04          0.00000       0.00000       0.00000     -0.107193E-07   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0           0.04          0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Main Engine      Gimbaling 
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   29750.0       29750.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   9.00000       120.000       2.60000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   84.5000       0.00000       0.00000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00        -3.50          0.00000    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Rght RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0   
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         3.50          0.00000    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Top  RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000      -3.50    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Botm RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000       3.50    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438     0.00       0.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438     0.00       0.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438     0.00       0.00    

Number of Slosh Modes                                                                    :  2
LOX Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft)  :  3.1   3.12  3.12   0.001  0.001   97.08  0.0  0.0   
LH2 Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft)  :  1.2   3.12  3.12   0.001  0.001   89.65  0.0  0.0  

Number of Bending Modes                                                                  : 10
Vehicle Second Stage Flex Modes with 100% Full Tanks
----------------------------------------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-2 Linear Actuator        
Symbol Parameter Description                    (Units)      Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.002, 0.002
Ka     Gain of Amplifier ...................... (amps/volt)   10.0    
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    60.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.0e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     1.8e+6
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.72   
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   120.0
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   3000.0    
----------------------------------------------------------------------------------------------------------------------------
                                  CREATE MATLAB DATA
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle Second Stage Analysis Model, T=180 sec
System
Vehicle
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-2 Linear Actuator     
System
actuator
----------------------------------------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : Stage-2 100% Full
Vehicle Second Stage Flex Modes with 100% Full Tanks
! Flex Modes for Second Stage with 100% Full Tanks less 20% Slosh
! Sensors are at the Top of LOX Tank at Node: 601
! The Modes were selected between the TVC (Node:3303) and the IMU Locat. (Node:601)

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    103.34       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303     0.26103D-11   0.95450D-01  -0.29391D-01   0.40458D-10  -0.46045D-02  -0.14953D-01
Stage-2 Gimbal                    3303     0.26103D-11   0.95450D-01  -0.29391D-01   0.40458D-10  -0.46045D-02  -0.14953D-01
Stage-2 Gimbal                    3303     0.26103D-11   0.95450D-01  -0.29391D-01   0.40458D-10  -0.46045D-02  -0.14953D-01
Stage-2 Gimbal                    3303     0.26103D-11   0.95450D-01  -0.29391D-01   0.40458D-10  -0.46045D-02  -0.14953D-01
Stage-2 Gimbal                    3303     0.26103D-11   0.95450D-01  -0.29391D-01   0.40458D-10  -0.46045D-02  -0.14953D-01

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601    -0.16444D-09  -0.39253D-01   0.12087D-01   0.30236D-10  -0.32603D-02  -0.10588D-01
LOX  Slosh Mass and IMU            601    -0.16444D-09  -0.39253D-01   0.12087D-01   0.30236D-10  -0.32603D-02  -0.10588D-01
LOX  Slosh Mass and IMU            601    -0.16444D-09  -0.39253D-01   0.12087D-01   0.30236D-10  -0.32603D-02  -0.10588D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.16444D-09  -0.39253D-01   0.12087D-01   0.30236D-10  -0.32603D-02  -0.10588D-01
Fuel Slosh Mass Locat.             600     0.22999D-09   0.11157D-01  -0.34354D-02  -0.75684D-10  -0.35882D-02  -0.11653D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.38576D-09   0.69496D+00  -0.21399D+00  -0.57660D-09   0.21046D-01   0.68348D-01

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    103.34       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303     0.56620D-12  -0.29391D-01  -0.95450D-01   0.90798D-11  -0.14953D-01   0.46045D-02
Stage-2 Gimbal                    3303     0.56620D-12  -0.29391D-01  -0.95450D-01   0.90798D-11  -0.14953D-01   0.46045D-02
Stage-2 Gimbal                    3303     0.56620D-12  -0.29391D-01  -0.95450D-01   0.90798D-11  -0.14953D-01   0.46045D-02
Stage-2 Gimbal                    3303     0.56620D-12  -0.29391D-01  -0.95450D-01   0.90798D-11  -0.14953D-01   0.46045D-02
Stage-2 Gimbal                    3303     0.56620D-12  -0.29391D-01  -0.95450D-01   0.90798D-11  -0.14953D-01   0.46045D-02

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601    -0.41465D-10   0.12087D-01   0.39253D-01   0.76672D-11  -0.10588D-01   0.32603D-02
LOX  Slosh Mass and IMU            601    -0.41465D-10   0.12087D-01   0.39253D-01   0.76672D-11  -0.10588D-01   0.32603D-02
LOX  Slosh Mass and IMU            601    -0.41465D-10   0.12087D-01   0.39253D-01   0.76672D-11  -0.10588D-01   0.32603D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.41465D-10   0.12087D-01   0.39253D-01   0.76672D-11  -0.10588D-01   0.32603D-02
Fuel Slosh Mass Locat.             600     0.51329D-10  -0.34354D-02  -0.11157D-01  -0.22084D-10  -0.11653D-01   0.35882D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.10773D-09  -0.21399D+00  -0.69496D+00  -0.16200D-09   0.68348D-01  -0.21046D-01

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    257.29       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303    -0.24599D-14  -0.16259D+00  -0.32801D+00   0.36311D-14  -0.82157D-01   0.40723D-01
Stage-2 Gimbal                    3303    -0.24599D-14  -0.16259D+00  -0.32801D+00   0.36311D-14  -0.82157D-01   0.40723D-01
Stage-2 Gimbal                    3303    -0.24599D-14  -0.16259D+00  -0.32801D+00   0.36311D-14  -0.82157D-01   0.40723D-01
Stage-2 Gimbal                    3303    -0.24599D-14  -0.16259D+00  -0.32801D+00   0.36311D-14  -0.82157D-01   0.40723D-01
Stage-2 Gimbal                    3303    -0.24599D-14  -0.16259D+00  -0.32801D+00   0.36311D-14  -0.82157D-01   0.40723D-01

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601    -0.88396D-13   0.39546D-01   0.79780D-01   0.32279D-13   0.82945D-03  -0.41114D-03
LOX  Slosh Mass and IMU            601    -0.88396D-13   0.39546D-01   0.79780D-01   0.32279D-13   0.82945D-03  -0.41114D-03
LOX  Slosh Mass and IMU            601    -0.88396D-13   0.39546D-01   0.79780D-01   0.32279D-13   0.82945D-03  -0.41114D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.88396D-13   0.39546D-01   0.79780D-01   0.32279D-13   0.82945D-03  -0.41114D-03
Fuel Slosh Mass Locat.             600     0.12286D-12  -0.69826D-02  -0.14087D-01  -0.39138D-13  -0.15065D-01   0.74672D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.18399D-12  -0.10098D-02  -0.20372D-02  -0.45029D-12   0.20476D-02  -0.10149D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    257.29       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303     0.68015D-13  -0.32801D+00   0.16259D+00   0.89272D-12   0.40723D-01   0.82157D-01
Stage-2 Gimbal                    3303     0.68015D-13  -0.32801D+00   0.16259D+00   0.89272D-12   0.40723D-01   0.82157D-01
Stage-2 Gimbal                    3303     0.68015D-13  -0.32801D+00   0.16259D+00   0.89272D-12   0.40723D-01   0.82157D-01
Stage-2 Gimbal                    3303     0.68015D-13  -0.32801D+00   0.16259D+00   0.89272D-12   0.40723D-01   0.82157D-01
Stage-2 Gimbal                    3303     0.68015D-13  -0.32801D+00   0.16259D+00   0.89272D-12   0.40723D-01   0.82157D-01

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601    -0.44726D-11   0.79780D-01  -0.39546D-01   0.91398D-12  -0.41114D-03  -0.82945D-03
LOX  Slosh Mass and IMU            601    -0.44726D-11   0.79780D-01  -0.39546D-01   0.91398D-12  -0.41114D-03  -0.82945D-03
LOX  Slosh Mass and IMU            601    -0.44726D-11   0.79780D-01  -0.39546D-01   0.91398D-12  -0.41114D-03  -0.82945D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.44726D-11   0.79780D-01  -0.39546D-01   0.91398D-12  -0.41114D-03  -0.82945D-03
Fuel Slosh Mass Locat.             600     0.59405D-11  -0.14087D-01   0.69826D-02  -0.21719D-11   0.74672D-02   0.15065D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.11037D-10  -0.20372D-02   0.10098D-02  -0.17066D-10  -0.10149D-02  -0.20476D-02

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    322.64       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303     0.68447D+00  -0.15009D-13  -0.22932D-14  -0.55201D-14   0.89707D-14   0.53826D-13
Stage-2 Gimbal                    3303     0.68447D+00  -0.15009D-13  -0.22932D-14  -0.55201D-14   0.89707D-14   0.53826D-13
Stage-2 Gimbal                    3303     0.68447D+00  -0.15009D-13  -0.22932D-14  -0.55201D-14   0.89707D-14   0.53826D-13
Stage-2 Gimbal                    3303     0.68447D+00  -0.15009D-13  -0.22932D-14  -0.55201D-14   0.89707D-14   0.53826D-13
Stage-2 Gimbal                    3303     0.68447D+00  -0.15009D-13  -0.22932D-14  -0.55201D-14   0.89707D-14   0.53826D-13

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601    -0.28533D-01   0.17395D-12  -0.19261D-12   0.59449D-13   0.75826D-15  -0.54930D-16
LOX  Slosh Mass and IMU            601    -0.28533D-01   0.17395D-12  -0.19261D-12   0.59449D-13   0.75826D-15  -0.54930D-16
LOX  Slosh Mass and IMU            601    -0.28533D-01   0.17395D-12  -0.19261D-12   0.59449D-13   0.75826D-15  -0.54930D-16

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.28533D-01   0.17395D-12  -0.19261D-12   0.59449D-13   0.75826D-15  -0.54930D-16
Fuel Slosh Mass Locat.             600    -0.11351D-01  -0.16148D-13   0.67484D-13  -0.91082D-13   0.86347D-15   0.76915D-15

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.41562D-01  -0.10077D-12   0.12216D-11  -0.93870D-12  -0.61090D-12  -0.31639D-14

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    342.74       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303     0.94822D-15   0.58613D-15   0.31067D-14  -0.14423D-01   0.96056D-14   0.50006D-14
Stage-2 Gimbal                    3303     0.94822D-15   0.58613D-15   0.31067D-14  -0.14423D-01   0.96056D-14   0.50006D-14
Stage-2 Gimbal                    3303     0.94822D-15   0.58613D-15   0.31067D-14  -0.14423D-01   0.96056D-14   0.50006D-14
Stage-2 Gimbal                    3303     0.94822D-15   0.58613D-15   0.31067D-14  -0.14423D-01   0.96056D-14   0.50006D-14
Stage-2 Gimbal                    3303     0.94822D-15   0.58613D-15   0.31067D-14  -0.14423D-01   0.96056D-14   0.50006D-14

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601     0.95070D-14  -0.13685D-13   0.13039D-13  -0.57322D-02  -0.30170D-15  -0.21848D-15
LOX  Slosh Mass and IMU            601     0.95070D-14  -0.13685D-13   0.13039D-13  -0.57322D-02  -0.30170D-15  -0.21848D-15
LOX  Slosh Mass and IMU            601     0.95070D-14  -0.13685D-13   0.13039D-13  -0.57322D-02  -0.30170D-15  -0.21848D-15

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.95070D-14  -0.13685D-13   0.13039D-13  -0.57322D-02  -0.30170D-15  -0.21848D-15
Fuel Slosh Mass Locat.             600    -0.18949D-13  -0.55140D-14   0.15376D-13  -0.12156D-01  -0.74387D-16  -0.27016D-15

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.31074D-13   0.53597D-13   0.12085D-13   0.26269D+00  -0.97381D-14   0.23588D-13

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    443.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303    -0.22687D-15  -0.81625D-01  -0.52725D+00   0.14208D-14  -0.27784D+00   0.43013D-01
Stage-2 Gimbal                    3303    -0.22687D-15  -0.81625D-01  -0.52725D+00   0.14208D-14  -0.27784D+00   0.43013D-01
Stage-2 Gimbal                    3303    -0.22687D-15  -0.81625D-01  -0.52725D+00   0.14208D-14  -0.27784D+00   0.43013D-01
Stage-2 Gimbal                    3303    -0.22687D-15  -0.81625D-01  -0.52725D+00   0.14208D-14  -0.27784D+00   0.43013D-01
Stage-2 Gimbal                    3303    -0.22687D-15  -0.81625D-01  -0.52725D+00   0.14208D-14  -0.27784D+00   0.43013D-01

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601    -0.92014D-14  -0.67282D-02  -0.43461D-01   0.17719D-14   0.72194D-02  -0.11176D-02
LOX  Slosh Mass and IMU            601    -0.92014D-14  -0.67282D-02  -0.43461D-01   0.17719D-14   0.72194D-02  -0.11176D-02
LOX  Slosh Mass and IMU            601    -0.92014D-14  -0.67282D-02  -0.43461D-01   0.17719D-14   0.72194D-02  -0.11176D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.92014D-14  -0.67282D-02  -0.43461D-01   0.17719D-14   0.72194D-02  -0.11176D-02
Fuel Slosh Mass Locat.             600     0.10970D-13   0.13079D-01   0.84486D-01  -0.46934D-14   0.26875D-02  -0.41606D-03

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.20202D-13   0.62700D-01   0.40501D+00  -0.36773D-13  -0.10694D+00   0.16555D-01

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    443.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303     0.12085D-15  -0.52725D+00   0.81625D-01  -0.35402D-14   0.43013D-01   0.27784D+00
Stage-2 Gimbal                    3303     0.12085D-15  -0.52725D+00   0.81625D-01  -0.35402D-14   0.43013D-01   0.27784D+00
Stage-2 Gimbal                    3303     0.12085D-15  -0.52725D+00   0.81625D-01  -0.35402D-14   0.43013D-01   0.27784D+00
Stage-2 Gimbal                    3303     0.12085D-15  -0.52725D+00   0.81625D-01  -0.35402D-14   0.43013D-01   0.27784D+00
Stage-2 Gimbal                    3303     0.12085D-15  -0.52725D+00   0.81625D-01  -0.35402D-14   0.43013D-01   0.27784D+00

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601     0.16253D-13  -0.43461D-01   0.67282D-02  -0.22397D-14  -0.11176D-02  -0.72194D-02
LOX  Slosh Mass and IMU            601     0.16253D-13  -0.43461D-01   0.67282D-02  -0.22397D-14  -0.11176D-02  -0.72194D-02
LOX  Slosh Mass and IMU            601     0.16253D-13  -0.43461D-01   0.67282D-02  -0.22397D-14  -0.11176D-02  -0.72194D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.16253D-13  -0.43461D-01   0.67282D-02  -0.22397D-14  -0.11176D-02  -0.72194D-02
Fuel Slosh Mass Locat.             600    -0.24519D-13   0.84486D-01  -0.13079D-01   0.65159D-14  -0.41606D-03  -0.26875D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.41933D-13   0.40501D+00  -0.62700D-01   0.43399D-13   0.16555D-01   0.10694D+00

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    480.60       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303    -0.68291D-15  -0.20314D+00  -0.34069D+00  -0.53761D-16  -0.20347D+00   0.12132D+00
Stage-2 Gimbal                    3303    -0.68291D-15  -0.20314D+00  -0.34069D+00  -0.53761D-16  -0.20347D+00   0.12132D+00
Stage-2 Gimbal                    3303    -0.68291D-15  -0.20314D+00  -0.34069D+00  -0.53761D-16  -0.20347D+00   0.12132D+00
Stage-2 Gimbal                    3303    -0.68291D-15  -0.20314D+00  -0.34069D+00  -0.53761D-16  -0.20347D+00   0.12132D+00
Stage-2 Gimbal                    3303    -0.68291D-15  -0.20314D+00  -0.34069D+00  -0.53761D-16  -0.20347D+00   0.12132D+00

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601     0.71635D-15  -0.19490D-01  -0.32688D-01  -0.23100D-15  -0.31789D-02   0.18954D-02
LOX  Slosh Mass and IMU            601     0.71635D-15  -0.19490D-01  -0.32688D-01  -0.23100D-15  -0.31789D-02   0.18954D-02
LOX  Slosh Mass and IMU            601     0.71635D-15  -0.19490D-01  -0.32688D-01  -0.23100D-15  -0.31789D-02   0.18954D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.71635D-15  -0.19490D-01  -0.32688D-01  -0.23100D-15  -0.31789D-02   0.18954D-02
Fuel Slosh Mass Locat.             600    -0.64246D-15   0.27677D-01   0.46418D-01   0.54458D-15   0.21896D-02  -0.13056D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.51139D-15  -0.27699D+00  -0.46454D+00   0.44490D-14   0.12594D+00  -0.75091D-01

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    480.60       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303    -0.29368D-15   0.34069D+00  -0.20314D+00  -0.86328D-15  -0.12132D+00  -0.20347D+00
Stage-2 Gimbal                    3303    -0.29368D-15   0.34069D+00  -0.20314D+00  -0.86328D-15  -0.12132D+00  -0.20347D+00
Stage-2 Gimbal                    3303    -0.29368D-15   0.34069D+00  -0.20314D+00  -0.86328D-15  -0.12132D+00  -0.20347D+00
Stage-2 Gimbal                    3303    -0.29368D-15   0.34069D+00  -0.20314D+00  -0.86328D-15  -0.12132D+00  -0.20347D+00
Stage-2 Gimbal                    3303    -0.29368D-15   0.34069D+00  -0.20314D+00  -0.86328D-15  -0.12132D+00  -0.20347D+00

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601     0.73439D-14   0.32688D-01  -0.19490D-01  -0.12756D-14  -0.18954D-02  -0.31789D-02
LOX  Slosh Mass and IMU            601     0.73439D-14   0.32688D-01  -0.19490D-01  -0.12756D-14  -0.18954D-02  -0.31789D-02
LOX  Slosh Mass and IMU            601     0.73439D-14   0.32688D-01  -0.19490D-01  -0.12756D-14  -0.18954D-02  -0.31789D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.73439D-14   0.32688D-01  -0.19490D-01  -0.12756D-14  -0.18954D-02  -0.31789D-02
Fuel Slosh Mass Locat.             600    -0.91280D-14  -0.46418D-01   0.27677D-01   0.38334D-14   0.13056D-02   0.21896D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.13702D-13   0.46454D+00  -0.27699D+00   0.31454D-13   0.75091D-01   0.12594D+00

MODE# 11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    604.21       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303    -0.28105D-17   0.55151D-16  -0.10078D-15  -0.81121D-01  -0.85804D-16  -0.43534D-16
Stage-2 Gimbal                    3303    -0.28105D-17   0.55151D-16  -0.10078D-15  -0.81121D-01  -0.85804D-16  -0.43534D-16
Stage-2 Gimbal                    3303    -0.28105D-17   0.55151D-16  -0.10078D-15  -0.81121D-01  -0.85804D-16  -0.43534D-16
Stage-2 Gimbal                    3303    -0.28105D-17   0.55151D-16  -0.10078D-15  -0.81121D-01  -0.85804D-16  -0.43534D-16
Stage-2 Gimbal                    3303    -0.28105D-17   0.55151D-16  -0.10078D-15  -0.81121D-01  -0.85804D-16  -0.43534D-16

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601    -0.18805D-17   0.12802D-17  -0.50969D-17   0.24278D-01  -0.15007D-17  -0.39514D-17
LOX  Slosh Mass and IMU            601    -0.18805D-17   0.12802D-17  -0.50969D-17   0.24278D-01  -0.15007D-17  -0.39514D-17
LOX  Slosh Mass and IMU            601    -0.18805D-17   0.12802D-17  -0.50969D-17   0.24278D-01  -0.15007D-17  -0.39514D-17

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.18805D-17   0.12802D-17  -0.50969D-17   0.24278D-01  -0.15007D-17  -0.39514D-17
Fuel Slosh Mass Locat.             600     0.76661D-17  -0.87905D-17  -0.81934D-17  -0.41906D-01   0.86398D-17  -0.12094D-18

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.31602D-16  -0.21535D-16  -0.10567D-15  -0.21730D-01   0.32461D-16  -0.13678D-16

MODE# 12/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    607.58       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                    3303     0.59069D-01   0.12266D-15  -0.34641D-15  -0.43264D-16  -0.14558D-15  -0.31902D-16
Stage-2 Gimbal                    3303     0.59069D-01   0.12266D-15  -0.34641D-15  -0.43264D-16  -0.14558D-15  -0.31902D-16
Stage-2 Gimbal                    3303     0.59069D-01   0.12266D-15  -0.34641D-15  -0.43264D-16  -0.14558D-15  -0.31902D-16
Stage-2 Gimbal                    3303     0.59069D-01   0.12266D-15  -0.34641D-15  -0.43264D-16  -0.14558D-15  -0.31902D-16
Stage-2 Gimbal                    3303     0.59069D-01   0.12266D-15  -0.34641D-15  -0.43264D-16  -0.14558D-15  -0.31902D-16

                              Node ID#     Modal Data at the  3 Gyros ...
LOX  Slosh Mass and IMU            601     0.22524D-01   0.55323D-17   0.84443D-16  -0.11515D-16  -0.59738D-17   0.20647D-16
LOX  Slosh Mass and IMU            601     0.22524D-01   0.55323D-17   0.84443D-16  -0.11515D-16  -0.59738D-17   0.20647D-16
LOX  Slosh Mass and IMU            601     0.22524D-01   0.55323D-17   0.84443D-16  -0.11515D-16  -0.59738D-17   0.20647D-16

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.22524D-01   0.55323D-17   0.84443D-16  -0.11515D-16  -0.59738D-17   0.20647D-16
Fuel Slosh Mass Locat.             600    -0.96829D-01  -0.26999D-16  -0.28976D-16  -0.27436D-16  -0.42730D-17   0.57118D-17

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.38639D+00   0.26418D-15   0.37073D-16   0.21352D-16  -0.30858D-16   0.83347D-16
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
