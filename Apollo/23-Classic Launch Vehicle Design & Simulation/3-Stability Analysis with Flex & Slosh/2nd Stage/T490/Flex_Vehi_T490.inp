BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Launch Vehicle systems during Second Stage
! This batch set creates state-space systems for the Flexible Launch Vehicle during 
! Second Stage, the Mixing Logic matrix and also the 2nd Stage Actuator. 
! 
Flight Vehicle   : Launch Vehicle Second Stage Analysis Model at T=490 sec         
Actuator Model   : Stage-2 Linear Actuator
Mixing Matrix    : Mixing Logic Matrix for Second Stage Vehicle at t=490 sec
!
To Matlab Format : Launch Vehicle Second Stage Analysis Model at T=490 sec          
To Matlab Format : Stage-2 Linear Actuator
To Matlab Format : Mixing Logic Matrix for Second Stage Vehicle at t=490 sec
-----------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle Second Stage Analysis Model at T=490 sec         
! This is the Analysis Model of Second Stage Vehicle consisting of the main engine
! and four bi-directional RCS jets. It includes Slosh and Flexibility
!
Body Axes Output, Attitude=Rate Integral             
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   192.402       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   1143.40       14582.5       14423.5       0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   94.6085       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   13.3710       25616.0      0.100000E-04   585285.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   155.108       154.633      0.559000E-01 -0.114000E-01
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   2.25000     -0.188000     -0.299984E-01  0.279983    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          1.36600       0.00000      0.0           -0.0782       -0.2808    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.000        90.000                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   38.5000       7.20000       7.20000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   116.800       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.410661      0.200003E-03  0.167632E-06   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.528967E-02 -0.281267E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.756564E-01 -0.431500E-01   0.00000       0.00000       0.00000       0.00000     -0.241121E-06
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.787676E-01 -0.612000E-01   0.00000       0.00000       0.00000     -0.604732E-06   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}: -0.375422E-02  0.199633E-01   0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Main Engine      Gimbaling 
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   29751.7       29751.7    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   9.00000       120.000       2.60000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   84.5000       0.00000       0.00000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00        -3.50          0.00000    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Rght RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0   
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         3.50          0.00000    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Top  RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000      -3.50    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Botm RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000       3.50    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438     0.00       0.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438     0.00       0.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438     0.00       0.00    

Number of Slosh Modes                                                                    :  2
LOX  Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :  17.226  3.12  3.12  0.001  0.001  90.194  0.0  0.0   
Fuel Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :  5.953   3.12  3.12  0.001  0.001  83.750  0.0  0.0  

Number of Bending Modes                                                                  :  8
Flex Modes of Vehicle Second Stage with Empty Tanks
----------------------------------------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-2 Linear Actuator        
Symbol Parameter Description                    (Units)      Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.002, 0.002
Ka     Gain of Amplifier ...................... (amps/volt)   10.0    
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    60.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.0e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     1.8e+6
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.72   
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   120.0
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   3000.0    
----------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Matrix for Second Stage Vehicle at t=490 sec
! Mixing Logic Matrix for the Second Stage Vehicle
!
Kmix_t490
Launch Vehicle Second Stage Analysis Model at T=490 sec
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
                                  CREATE MATLAB DATA
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle Second Stage Analysis Model at T=490 sec 
System
Vehicle
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-2 Linear Actuator     
System
actuator
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Matrix for Second Stage Vehicle at t=490 sec
Matrix Kmix_t490
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : Stage-2 Empty with Engines
Flex Modes of Vehicle Second Stage with Empty Tanks
! Flex Modes for Second Stage with Empty Tanks, from File Stage2_0%.Mod
! Sensors are at the Top of LOX Tank at Node: 604
! The Modes were selected between the TVC (Node:10408) and the IMU Locat. (Node:604)

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.161       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.10937D-01  -0.43777D-01  -0.45164D-01  -0.28800D-03   0.10322D+00  -0.10172D+00
Stage-2 Gimbal                   10408     0.10937D-01  -0.43777D-01  -0.45164D-01  -0.28800D-03   0.10322D+00  -0.10172D+00
Stage-2 Gimbal                   10408     0.10937D-01  -0.43777D-01  -0.45164D-01  -0.28800D-03   0.10322D+00  -0.10172D+00
Stage-2 Gimbal                   10408     0.10937D-01  -0.43777D-01  -0.45164D-01  -0.28800D-03   0.10322D+00  -0.10172D+00
Stage-2 Gimbal                   10408     0.10937D-01  -0.43777D-01  -0.45164D-01  -0.28800D-03   0.10322D+00  -0.10172D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.43980D-02  -0.82445D-01  -0.89207D-01   0.60000D-04  -0.87240D-02   0.80640D-02
Stage-2 Tank Top, IMU Location     604    -0.43980D-02  -0.82445D-01  -0.89207D-01   0.60000D-04  -0.87240D-02   0.80640D-02
Stage-2 Tank Top, IMU Location     604    -0.43980D-02  -0.82445D-01  -0.89207D-01   0.60000D-04  -0.87240D-02   0.80640D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.43880D-02  -0.99808D-01  -0.10799D+00   0.60000D-04  -0.85440D-02   0.78960D-02
Fuel Slosh Mass Locat.             600    -0.43560D-02  -0.14012D+00  -0.15159D+00   0.60000D-04  -0.80880D-02   0.74760D-02

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008    -0.44420D-02   0.39695D-01   0.42883D-01   0.60000D-04  -0.14616D-01   0.13512D-01

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    70.298       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.52300D-03   0.16913D-01  -0.11878D-01   0.10536D-01   0.12474D+00   0.13444D+00
Stage-2 Gimbal                   10408     0.52300D-03   0.16913D-01  -0.11878D-01   0.10536D-01   0.12474D+00   0.13444D+00
Stage-2 Gimbal                   10408     0.52300D-03   0.16913D-01  -0.11878D-01   0.10536D-01   0.12474D+00   0.13444D+00
Stage-2 Gimbal                   10408     0.52300D-03   0.16913D-01  -0.11878D-01   0.10536D-01   0.12474D+00   0.13444D+00
Stage-2 Gimbal                   10408     0.52300D-03   0.16913D-01  -0.11878D-01   0.10536D-01   0.12474D+00   0.13444D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.20800D-03   0.94609D-01  -0.88125D-01   0.26400D-03  -0.77760D-02  -0.83520D-02
Stage-2 Tank Top, IMU Location     604     0.20800D-03   0.94609D-01  -0.88125D-01   0.26400D-03  -0.77760D-02  -0.83520D-02
Stage-2 Tank Top, IMU Location     604     0.20800D-03   0.94609D-01  -0.88125D-01   0.26400D-03  -0.77760D-02  -0.83520D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.20700D-03   0.11255D+00  -0.10483D+00   0.25200D-03  -0.75480D-02  -0.81120D-02
Fuel Slosh Mass Locat.             600     0.20500D-03   0.15332D+00  -0.14280D+00   0.25200D-03  -0.70080D-02  -0.75360D-02

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008     0.21000D-03  -0.42376D-01   0.39355D-01   0.26400D-03  -0.14916D-01  -0.16032D-01

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    143.99       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.22500D-03  -0.33850D-02  -0.38230D-02  -0.95915D+00   0.91440D-02  -0.21600D-03
Stage-2 Gimbal                   10408     0.22500D-03  -0.33850D-02  -0.38230D-02  -0.95915D+00   0.91440D-02  -0.21600D-03
Stage-2 Gimbal                   10408     0.22500D-03  -0.33850D-02  -0.38230D-02  -0.95915D+00   0.91440D-02  -0.21600D-03
Stage-2 Gimbal                   10408     0.22500D-03  -0.33850D-02  -0.38230D-02  -0.95915D+00   0.91440D-02  -0.21600D-03
Stage-2 Gimbal                   10408     0.22500D-03  -0.33850D-02  -0.38230D-02  -0.95915D+00   0.91440D-02  -0.21600D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.50000D-04   0.13770D-02   0.69500D-03   0.24840D-01   0.24000D-04   0.13200D-03
Stage-2 Tank Top, IMU Location     604    -0.50000D-04   0.13770D-02   0.69500D-03   0.24840D-01   0.24000D-04   0.13200D-03
Stage-2 Tank Top, IMU Location     604    -0.50000D-04   0.13770D-02   0.69500D-03   0.24840D-01   0.24000D-04   0.13200D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.49000D-04   0.10790D-02   0.74500D-03   0.24648D-01   0.24000D-04   0.14400D-03
Fuel Slosh Mass Locat.             600    -0.47000D-04   0.18200D-03   0.84800D-03   0.24072D-01   0.36000D-04   0.16800D-03

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008    -0.53000D-04   0.12000D-04   0.14400D-03   0.30360D-01   0.84000D-04  -0.44400D-03

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    183.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.24097D-01   0.22285D+00   0.25151D+00  -0.56400D-02   0.40440D-02   0.51720D-02
Stage-2 Gimbal                   10408    -0.24097D-01   0.22285D+00   0.25151D+00  -0.56400D-02   0.40440D-02   0.51720D-02
Stage-2 Gimbal                   10408    -0.24097D-01   0.22285D+00   0.25151D+00  -0.56400D-02   0.40440D-02   0.51720D-02
Stage-2 Gimbal                   10408    -0.24097D-01   0.22285D+00   0.25151D+00  -0.56400D-02   0.40440D-02   0.51720D-02
Stage-2 Gimbal                   10408    -0.24097D-01   0.22285D+00   0.25151D+00  -0.56400D-02   0.40440D-02   0.51720D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.55370D-02  -0.12074D+00  -0.13371D+00   0.12000D-04   0.32556D-01  -0.29448D-01
Stage-2 Tank Top, IMU Location     604     0.55370D-02  -0.12074D+00  -0.13371D+00   0.12000D-04   0.32556D-01  -0.29448D-01
Stage-2 Tank Top, IMU Location     604     0.55370D-02  -0.12074D+00  -0.13371D+00   0.12000D-04   0.32556D-01  -0.29448D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.54280D-02  -0.51309D-01  -0.56936D-01   0.12000D-04   0.33900D-01  -0.30672D-01
Fuel Slosh Mass Locat.             600     0.50800D-02   0.13054D+00   0.14414D+00   0.12000D-04   0.35664D-01  -0.32268D-01

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008     0.60400D-02  -0.71472D-01  -0.79092D-01   0.24000D-04  -0.59856D-01   0.54108D-01

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    186.27       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.26200D-03  -0.22102D+00   0.20203D+00  -0.18120D-02  -0.32556D-01  -0.36660D-01
Stage-2 Gimbal                   10408     0.26200D-03  -0.22102D+00   0.20203D+00  -0.18120D-02  -0.32556D-01  -0.36660D-01
Stage-2 Gimbal                   10408     0.26200D-03  -0.22102D+00   0.20203D+00  -0.18120D-02  -0.32556D-01  -0.36660D-01
Stage-2 Gimbal                   10408     0.26200D-03  -0.22102D+00   0.20203D+00  -0.18120D-02  -0.32556D-01  -0.36660D-01
Stage-2 Gimbal                   10408     0.26200D-03  -0.22102D+00   0.20203D+00  -0.18120D-02  -0.32556D-01  -0.36660D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.18100D-03   0.12867D+00  -0.11604D+00  -0.68400D-03   0.30516D-01   0.33864D-01
Stage-2 Tank Top, IMU Location     604    -0.18100D-03   0.12867D+00  -0.11604D+00  -0.68400D-03   0.30516D-01   0.33864D-01
Stage-2 Tank Top, IMU Location     604    -0.18100D-03   0.12867D+00  -0.11604D+00  -0.68400D-03   0.30516D-01   0.33864D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.17800D-03   0.48790D-01  -0.44072D-01  -0.67200D-03   0.31692D-01   0.35172D-01
Fuel Slosh Mass Locat.             600    -0.16600D-03  -0.15894D+00   0.14311D+00  -0.64800D-03   0.33168D-01   0.36816D-01

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008    -0.19800D-03   0.83754D-01  -0.75505D-01  -0.98400D-03  -0.54180D-01  -0.60108D-01

MODE#  6/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    426.02       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.27247D-01  -0.10263D+00  -0.18678D+00  -0.13344D-01  -0.14050D+00   0.77040D-01
Stage-2 Gimbal                   10408    -0.27247D-01  -0.10263D+00  -0.18678D+00  -0.13344D-01  -0.14050D+00   0.77040D-01
Stage-2 Gimbal                   10408    -0.27247D-01  -0.10263D+00  -0.18678D+00  -0.13344D-01  -0.14050D+00   0.77040D-01
Stage-2 Gimbal                   10408    -0.27247D-01  -0.10263D+00  -0.18678D+00  -0.13344D-01  -0.14050D+00   0.77040D-01
Stage-2 Gimbal                   10408    -0.27247D-01  -0.10263D+00  -0.18678D+00  -0.13344D-01  -0.14050D+00   0.77040D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.29120D-02   0.22787D-01   0.35307D-01   0.11320D+00   0.80520D-02  -0.52200D-02
Stage-2 Tank Top, IMU Location     604     0.29120D-02   0.22787D-01   0.35307D-01   0.11320D+00   0.80520D-02  -0.52200D-02
Stage-2 Tank Top, IMU Location     604     0.29120D-02   0.22787D-01   0.35307D-01   0.11320D+00   0.80520D-02  -0.52200D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.24530D-02   0.36733D-01   0.56757D-01   0.11772D+00   0.68880D-02  -0.44520D-02
Fuel Slosh Mass Locat.             600     0.11340D-02   0.48022D-01   0.74201D-01   0.12486D+00   0.41400D-02  -0.26160D-02

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008     0.52270D-02  -0.33798D-01  -0.51682D-01  -0.19818D+00  -0.72480D-02   0.47400D-02

MODE#  7/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    426.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.73751D-01   0.29154D+00   0.49066D+00  -0.87840D-02   0.37928D+00  -0.21511D+00
Stage-2 Gimbal                   10408     0.73751D-01   0.29154D+00   0.49066D+00  -0.87840D-02   0.37928D+00  -0.21511D+00
Stage-2 Gimbal                   10408     0.73751D-01   0.29154D+00   0.49066D+00  -0.87840D-02   0.37928D+00  -0.21511D+00
Stage-2 Gimbal                   10408     0.73751D-01   0.29154D+00   0.49066D+00  -0.87840D-02   0.37928D+00  -0.21511D+00
Stage-2 Gimbal                   10408     0.73751D-01   0.29154D+00   0.49066D+00  -0.87840D-02   0.37928D+00  -0.21511D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.78600D-02  -0.60745D-01  -0.98421D-01   0.42228D-01  -0.22308D-01   0.13812D-01
Stage-2 Tank Top, IMU Location     604    -0.78600D-02  -0.60745D-01  -0.98421D-01   0.42228D-01  -0.22308D-01   0.13812D-01
Stage-2 Tank Top, IMU Location     604    -0.78600D-02  -0.60745D-01  -0.98421D-01   0.42228D-01  -0.22308D-01   0.13812D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.66120D-02  -0.97735D-01  -0.15787D+00   0.43896D-01  -0.19044D-01   0.11760D-01
Fuel Slosh Mass Locat.             600    -0.30310D-02  -0.12724D+00  -0.20553D+00   0.46500D-01  -0.11388D-01   0.68760D-02

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008    -0.14151D-01   0.90127D-01   0.14391D+00  -0.73176D-01   0.20112D-01  -0.12600D-01

MODE#  8/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    480.87       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.16131D-01  -0.42249D+00   0.27073D+00  -0.19440D-02   0.10675D+00   0.24511D+00
Stage-2 Gimbal                   10408    -0.16131D-01  -0.42249D+00   0.27073D+00  -0.19440D-02   0.10675D+00   0.24511D+00
Stage-2 Gimbal                   10408    -0.16131D-01  -0.42249D+00   0.27073D+00  -0.19440D-02   0.10675D+00   0.24511D+00
Stage-2 Gimbal                   10408    -0.16131D-01  -0.42249D+00   0.27073D+00  -0.19440D-02   0.10675D+00   0.24511D+00
Stage-2 Gimbal                   10408    -0.16131D-01  -0.42249D+00   0.27073D+00  -0.19440D-02   0.10675D+00   0.24511D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.13460D-02   0.14137D+00  -0.85262D-01   0.98400D-03  -0.11868D-01  -0.19620D-01
Stage-2 Tank Top, IMU Location     604     0.13460D-02   0.14137D+00  -0.85262D-01   0.98400D-03  -0.11868D-01  -0.19620D-01
Stage-2 Tank Top, IMU Location     604     0.13460D-02   0.14137D+00  -0.85262D-01   0.98400D-03  -0.11868D-01  -0.19620D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.10140D-02   0.19657D+00  -0.11843D+00   0.99600D-03  -0.86640D-02  -0.14244D-01
Fuel Slosh Mass Locat.             600     0.10100D-03   0.18051D+00  -0.10908D+00   0.99600D-03  -0.18720D-02  -0.26520D-02

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008     0.30710D-02  -0.20387D+00   0.12170D+00  -0.98400D-03   0.12648D-01   0.21192D-01
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : Stage-2 Empty No Engines
Terran Second Stage Flex Modes with Empty Tanks No Engines
! Flex Modes for Second Stage with Empty Tanks, case S2_00
! Sensors are at the Top of LOX Tank at Node: 604
! The Modes were selected between the TVC (Node:10408) and the IMU Locat. (Node:604)

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    188.58       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.25680D-02  -0.36926D+00  -0.29646D+00  -0.15480D-02  -0.45576D-01   0.56400D-01
Stage-2 Gimbal                   10408    -0.25680D-02  -0.36926D+00  -0.29646D+00  -0.15480D-02  -0.45576D-01   0.56400D-01
Stage-2 Gimbal                   10408    -0.25680D-02  -0.36926D+00  -0.29646D+00  -0.15480D-02  -0.45576D-01   0.56400D-01
Stage-2 Gimbal                   10408    -0.25680D-02  -0.36926D+00  -0.29646D+00  -0.15480D-02  -0.45576D-01   0.56400D-01
Stage-2 Gimbal                   10408    -0.25680D-02  -0.36926D+00  -0.29646D+00  -0.15480D-02  -0.45576D-01   0.56400D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.84200D-03   0.12754D+00   0.10234D+00   0.00000D+00  -0.30780D-01   0.38364D-01
Stage-2 Tank Top, IMU Location     604     0.84200D-03   0.12754D+00   0.10234D+00   0.00000D+00  -0.30780D-01   0.38364D-01
Stage-2 Tank Top, IMU Location     604     0.84200D-03   0.12754D+00   0.10234D+00   0.00000D+00  -0.30780D-01   0.38364D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.82400D-03   0.37380D-01   0.30000D-01   0.00000D+00  -0.31920D-01   0.39792D-01
Fuel Slosh Mass Locat.             600     0.76800D-03  -0.19558D+00  -0.15690D+00   0.00000D+00  -0.33420D-01   0.41664D-01

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008     0.92300D-03   0.92873D-01   0.74515D-01   0.12000D-04   0.51972D-01  -0.64776D-01

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    188.58       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.14300D-03  -0.29622D+00   0.36925D+00   0.61920D-02   0.56604D-01   0.45228D-01
Stage-2 Gimbal                   10408     0.14300D-03  -0.29622D+00   0.36925D+00   0.61920D-02   0.56604D-01   0.45228D-01
Stage-2 Gimbal                   10408     0.14300D-03  -0.29622D+00   0.36925D+00   0.61920D-02   0.56604D-01   0.45228D-01
Stage-2 Gimbal                   10408     0.14300D-03  -0.29622D+00   0.36925D+00   0.61920D-02   0.56604D-01   0.45228D-01
Stage-2 Gimbal                   10408     0.14300D-03  -0.29622D+00   0.36925D+00   0.61920D-02   0.56604D-01   0.45228D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.12000D-04   0.10233D+00  -0.12755D+00  -0.90000D-03   0.38364D-01   0.30780D-01
Stage-2 Tank Top, IMU Location     604    -0.12000D-04   0.10233D+00  -0.12755D+00  -0.90000D-03   0.38364D-01   0.30780D-01
Stage-2 Tank Top, IMU Location     604    -0.12000D-04   0.10233D+00  -0.12755D+00  -0.90000D-03   0.38364D-01   0.30780D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.12000D-04   0.29978D-01  -0.37376D-01  -0.88800D-03   0.39792D-01   0.31932D-01
Fuel Slosh Mass Locat.             600    -0.11000D-04  -0.15694D+00   0.19559D+00  -0.84000D-03   0.41664D-01   0.33432D-01

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008    -0.13000D-04   0.74523D-01  -0.92885D-01  -0.13080D-02  -0.64776D-01  -0.51972D-01

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    425.53       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.18300D-03   0.88800D-03  -0.65000D-03   0.14728D+00   0.15720D-02   0.15720D-02
Stage-2 Gimbal                   10408    -0.18300D-03   0.88800D-03  -0.65000D-03   0.14728D+00   0.15720D-02   0.15720D-02
Stage-2 Gimbal                   10408    -0.18300D-03   0.88800D-03  -0.65000D-03   0.14728D+00   0.15720D-02   0.15720D-02
Stage-2 Gimbal                   10408    -0.18300D-03   0.88800D-03  -0.65000D-03   0.14728D+00   0.15720D-02   0.15720D-02
Stage-2 Gimbal                   10408    -0.18300D-03   0.88800D-03  -0.65000D-03   0.14728D+00   0.15720D-02   0.15720D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.90000D-05   0.16210D-02  -0.20700D-02   0.12022D+00  -0.46800D-03  -0.37200D-03
Stage-2 Tank Top, IMU Location     604     0.90000D-05   0.16210D-02  -0.20700D-02   0.12022D+00  -0.46800D-03  -0.37200D-03
Stage-2 Tank Top, IMU Location     604     0.90000D-05   0.16210D-02  -0.20700D-02   0.12022D+00  -0.46800D-03  -0.37200D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.80000D-05   0.25990D-02  -0.33190D-02   0.12506D+00  -0.40800D-03  -0.31200D-03
Fuel Slosh Mass Locat.             600     0.40000D-05   0.34060D-02  -0.43500D-02   0.13273D+00  -0.25200D-03  -0.19200D-03

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008     0.16000D-04  -0.23280D-02   0.29730D-02  -0.21179D+00   0.42000D-03   0.32400D-03

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    429.74       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.11000D+01   0.22610D+00   0.19087D+00   0.12240D-02   0.15266D+00  -0.18552D+00
Stage-2 Gimbal                   10408     0.11000D+01   0.22610D+00   0.19087D+00   0.12240D-02   0.15266D+00  -0.18552D+00
Stage-2 Gimbal                   10408     0.11000D+01   0.22610D+00   0.19087D+00   0.12240D-02   0.15266D+00  -0.18552D+00
Stage-2 Gimbal                   10408     0.11000D+01   0.22610D+00   0.19087D+00   0.12240D-02   0.15266D+00  -0.18552D+00
Stage-2 Gimbal                   10408     0.11000D+01   0.22610D+00   0.19087D+00   0.12240D-02   0.15266D+00  -0.18552D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.59145D-01  -0.87710D-02  -0.75620D-02   0.12000D-04  -0.17640D-02   0.20640D-02
Stage-2 Tank Top, IMU Location     604    -0.59145D-01  -0.87710D-02  -0.75620D-02   0.12000D-04  -0.17640D-02   0.20640D-02
Stage-2 Tank Top, IMU Location     604    -0.59145D-01  -0.87710D-02  -0.75620D-02   0.12000D-04  -0.17640D-02   0.20640D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.49546D-01  -0.14726D-01  -0.12636D-01   0.12000D-04  -0.14160D-02   0.16440D-02
Fuel Slosh Mass Locat.             600    -0.22035D-01  -0.18825D-01  -0.16158D-01   0.12000D-04  -0.49200D-03   0.54000D-03

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008    -0.10765D+00   0.16228D-01   0.13724D-01  -0.24000D-04   0.18960D-02  -0.22440D-02

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    578.17       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.21731D-01   0.84446D+00  -0.83195D+00  -0.83400D-01  -0.38185D+00  -0.38681D+00
Stage-2 Gimbal                   10408    -0.21731D-01   0.84446D+00  -0.83195D+00  -0.83400D-01  -0.38185D+00  -0.38681D+00
Stage-2 Gimbal                   10408    -0.21731D-01   0.84446D+00  -0.83195D+00  -0.83400D-01  -0.38185D+00  -0.38681D+00
Stage-2 Gimbal                   10408    -0.21731D-01   0.84446D+00  -0.83195D+00  -0.83400D-01  -0.38185D+00  -0.38681D+00
Stage-2 Gimbal                   10408    -0.21731D-01   0.84446D+00  -0.83195D+00  -0.83400D-01  -0.38185D+00  -0.38681D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.29300D-03  -0.17606D+00   0.17409D+00   0.29760D-02  -0.27960D-02  -0.28440D-02
Stage-2 Tank Top, IMU Location     604     0.29300D-03  -0.17606D+00   0.17409D+00   0.29760D-02  -0.27960D-02  -0.28440D-02
Stage-2 Tank Top, IMU Location     604     0.29300D-03  -0.17606D+00   0.17409D+00   0.29760D-02  -0.27960D-02  -0.28440D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601     0.76000D-04  -0.17253D+00   0.17062D+00   0.29520D-02  -0.10680D-01  -0.10824D-01
Fuel Slosh Mass Locat.             600    -0.46200D-03   0.19871D-01  -0.19552D-01   0.27120D-02  -0.25392D-01  -0.25716D-01

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008     0.14970D-02   0.29206D+00  -0.28868D+00  -0.15960D-02  -0.12372D-01  -0.12516D-01

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    581.74       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.17887D+00  -0.76571D+00  -0.77962D+00  -0.32652D-01  -0.32803D+00   0.31912D+00
Stage-2 Gimbal                   10408     0.17887D+00  -0.76571D+00  -0.77962D+00  -0.32652D-01  -0.32803D+00   0.31912D+00
Stage-2 Gimbal                   10408     0.17887D+00  -0.76571D+00  -0.77962D+00  -0.32652D-01  -0.32803D+00   0.31912D+00
Stage-2 Gimbal                   10408     0.17887D+00  -0.76571D+00  -0.77962D+00  -0.32652D-01  -0.32803D+00   0.31912D+00
Stage-2 Gimbal                   10408     0.17887D+00  -0.76571D+00  -0.77962D+00  -0.32652D-01  -0.32803D+00   0.31912D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.27280D-02   0.17704D+00   0.18010D+00   0.42000D-03  -0.38640D-02   0.38040D-02
Stage-2 Tank Top, IMU Location     604    -0.27280D-02   0.17704D+00   0.18010D+00   0.42000D-03  -0.38640D-02   0.38040D-02
Stage-2 Tank Top, IMU Location     604    -0.27280D-02   0.17704D+00   0.18010D+00   0.42000D-03  -0.38640D-02   0.38040D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass and IMU            601    -0.58500D-03   0.17049D+00   0.17345D+00   0.42000D-03  -0.12000D-01   0.11808D-01
Fuel Slosh Mass Locat.             600     0.47160D-02  -0.28333D-01  -0.28761D-01   0.38400D-03  -0.26952D-01   0.26508D-01

                              Node ID#     Modal Data at the Disturbance Point 
Payload CG                       90008    -0.14688D-01  -0.29485D+00  -0.29988D+00  -0.21600D-03  -0.12168D-01   0.11964D-01
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
