BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Launch Vehicle systems during Second Stage
! This batch set creates state-space systems for the Flexible Launch Vehicle during 
! Second Stage and also for the 2nd Stage Actuator. 
! 
Flight Vehicle   : Launch Vehicle Second Stage Analysis Model at T=280 sec         
Actuator Model   : Stage-2 Linear Actuator
Mixing Matrix    : Mixing Logic Matrix for Second Stage Vehicle at t=280 sec
!
To Matlab Format : Launch Vehicle Second Stage Analysis Model at T=280 sec          
To Matlab Format : Stage-2 Linear Actuator
To Matlab Format : Mixing Logic Matrix for Second Stage Vehicle at t=280 sec
-----------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle Second Stage Analysis Model at T=280 sec                                                    
! This is the Analysis Model of Second Stage Vehicle consisting of the main engine
! and four bi-directional RCS jets. It includes Slosh and Flexibility
!
Body Axes Output, Attitude=Rate Integral             
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   718.374       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   4790.87       22960.4       22801.4       0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   91.8984       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   5.74000       10248.9      0.100000E-04   512293.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   36.2100       41.4153     -0.950000E-02  0.174000E-01
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   6.42100      -3.75900      0.300052E-01  0.100024    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          15.8070       0.00000       0.000        -0.108000     -0.0896
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.00000      90.00000                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   38.5000       7.20000       7.20000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   116.800       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.450125      0.149995E-03 -0.514195E-05   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.127243     -0.353150E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.290584     -0.632500E-01   0.00000       0.00000       0.00000       0.00000      0.939033E-06
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.429066     -0.117700       0.00000       0.00000       0.00000     -0.118214E-05   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}: -0.132872      0.398050E-01   0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Main Engine      Gimbaling 
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   29752.0       29752.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   9.00000       120.000       2.60000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   84.5000       0.00000       0.00000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00        -3.50          0.00000    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Rght RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0   
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         3.50          0.00000    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Top  RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000      -3.50    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Botm RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000       3.50    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438     0.00       0.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438     0.00       0.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438     0.00       0.00    

Number of Slosh Modes                                                                    :  2
LOX Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft)  :  119.25  3.12  3.12  0.02   0.02   94.912  0.0  0.0   
LH2 Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft)  :  41.12   3.12  3.12  0.002  0.002  87.808  0.0  0.0  

Number of Bending Modes                                                                  :  10
Vehicle Second Stage Flex Modes with 60% Full Tanks
----------------------------------------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-2 Linear Actuator        
Symbol Parameter Description                    (Units)      Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.002, 0.002
Ka     Gain of Amplifier ...................... (amps/volt)   10.0    
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    60.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.0e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     1.8e+6
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.72   
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   120.0
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   3000.0    
----------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Matrix for Second Stage Vehicle at t=280 sec
! Mixing Logic Matrix for the Second Stage Vehicle
!
Kmix_t280
Launch Vehicle Second Stage Analysis Model at T=280 sec
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
                                  CREATE MATLAB DATA
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle Second Stage Analysis Model at T=280 sec 
System
Vehicle
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-2 Linear Actuator     
System
actuator
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Matrix for Second Stage Vehicle at t=280 sec
Matrix Kmix_t280
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : Stage-2 60% Full Tanks
Vehicle Second Stage Flex Modes with 60% Full Tanks
! Flex Modes for Second Stage with 60% Full Tanks
! Sensors are at the Top of LOX Tank at Node: 604
! The Modes were selected between the TVC (Node:10408) and the IMU Locat. (Node:604)

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    57.559       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.12554D-01   0.66810D-01   0.75248D-01  -0.67516D-04   0.99892D-01  -0.97086D-01
Stage-2 Gimbal                   10408     0.12554D-01   0.66810D-01   0.75248D-01  -0.67516D-04   0.99892D-01  -0.97086D-01
Stage-2 Gimbal                   10408     0.12554D-01   0.66810D-01   0.75248D-01  -0.67516D-04   0.99892D-01  -0.97086D-01
Stage-2 Gimbal                   10408     0.12554D-01   0.66810D-01   0.75248D-01  -0.67516D-04   0.99892D-01  -0.97086D-01
Stage-2 Gimbal                   10408     0.12554D-01   0.66810D-01   0.75248D-01  -0.67516D-04   0.99892D-01  -0.97086D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.10772D-02  -0.10579D-01  -0.11529D-01  -0.32639D-05  -0.39832D-02   0.36599D-02
Stage-2 Tank Top, IMU Location     604    -0.10772D-02  -0.10579D-01  -0.11529D-01  -0.32639D-05  -0.39832D-02   0.36599D-02
Stage-2 Tank Top, IMU Location     604    -0.10772D-02  -0.10579D-01  -0.11529D-01  -0.32639D-05  -0.39832D-02   0.36599D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     601    -0.10770D-02  -0.11461D-01  -0.12489D-01  -0.32634D-05  -0.39642D-02   0.36425D-02
LH2 Slosh Mass Locat.              600    -0.10585D-02  -0.29142D-01  -0.31732D-01  -0.32018D-05  -0.34940D-02   0.32102D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.10874D-02   0.11991D+00   0.13046D+00  -0.33619D-05  -0.93956D-02   0.86347D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.719       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.28738D-03  -0.10265D+00   0.98963D-01   0.93041D-02   0.11725D+00   0.12703D+00
Stage-2 Gimbal                   10408     0.28738D-03  -0.10265D+00   0.98963D-01   0.93041D-02   0.11725D+00   0.12703D+00
Stage-2 Gimbal                   10408     0.28738D-03  -0.10265D+00   0.98963D-01   0.93041D-02   0.11725D+00   0.12703D+00
Stage-2 Gimbal                   10408     0.28738D-03  -0.10265D+00   0.98963D-01   0.93041D-02   0.11725D+00   0.12703D+00
Stage-2 Gimbal                   10408     0.28738D-03  -0.10265D+00   0.98963D-01   0.93041D-02   0.11725D+00   0.12703D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.56834D-04   0.13564D-01  -0.12558D-01  -0.18277D-04  -0.33616D-02  -0.36380D-02
Stage-2 Tank Top, IMU Location     604     0.56834D-04   0.13564D-01  -0.12558D-01  -0.18277D-04  -0.33616D-02  -0.36380D-02
Stage-2 Tank Top, IMU Location     604     0.56834D-04   0.13564D-01  -0.12558D-01  -0.18277D-04  -0.33616D-02  -0.36380D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.56821D-04   0.14456D-01  -0.13382D-01  -0.18275D-04  -0.33390D-02  -0.36136D-02
LH2 Slosh Mass Locat.              600     0.55625D-04   0.31437D-01  -0.29071D-01  -0.17852D-04  -0.27868D-02  -0.30152D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.57491D-04  -0.14221D+00   0.13133D+00  -0.18955D-04  -0.99155D-02  -0.10736D-01

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    137.97       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.11252D-01  -0.13982D+00  -0.14997D+00  -0.21668D-01   0.10346D-01  -0.14274D-01
Stage-2 Gimbal                   10408     0.11252D-01  -0.13982D+00  -0.14997D+00  -0.21668D-01   0.10346D-01  -0.14274D-01
Stage-2 Gimbal                   10408     0.11252D-01  -0.13982D+00  -0.14997D+00  -0.21668D-01   0.10346D-01  -0.14274D-01
Stage-2 Gimbal                   10408     0.11252D-01  -0.13982D+00  -0.14997D+00  -0.21668D-01   0.10346D-01  -0.14274D-01
Stage-2 Gimbal                   10408     0.11252D-01  -0.13982D+00  -0.14997D+00  -0.21668D-01   0.10346D-01  -0.14274D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.70254D-03   0.74901D-01   0.79406D-01   0.92965D-04  -0.19787D-01   0.18668D-01
Stage-2 Tank Top, IMU Location     604    -0.70254D-03   0.74901D-01   0.79406D-01   0.92965D-04  -0.19787D-01   0.18668D-01
Stage-2 Tank Top, IMU Location     604    -0.70254D-03   0.74901D-01   0.79406D-01   0.92965D-04  -0.19787D-01   0.18668D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.70175D-03   0.70755D-01   0.75012D-01   0.92899D-04  -0.19985D-01   0.18856D-01
LH2 Slosh Mass Locat.              600    -0.63245D-03  -0.48834D-01  -0.51746D-01   0.82706D-04  -0.22932D-01   0.21636D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.74208D-03  -0.43858D+00  -0.46488D+00   0.11165D-03   0.59105D-01  -0.55762D-01

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    139.04       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.20503D-03  -0.12798D+00   0.12112D+00  -0.22597D-01  -0.29677D-01  -0.32329D-01
Stage-2 Gimbal                   10408    -0.20503D-03  -0.12798D+00   0.12112D+00  -0.22597D-01  -0.29677D-01  -0.32329D-01
Stage-2 Gimbal                   10408    -0.20503D-03  -0.12798D+00   0.12112D+00  -0.22597D-01  -0.29677D-01  -0.32329D-01
Stage-2 Gimbal                   10408    -0.20503D-03  -0.12798D+00   0.12112D+00  -0.22597D-01  -0.29677D-01  -0.32329D-01
Stage-2 Gimbal                   10408    -0.20503D-03  -0.12798D+00   0.12112D+00  -0.22597D-01  -0.29677D-01  -0.32329D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.11575D-04   0.79253D-01  -0.74800D-01   0.10612D-04   0.18972D-01   0.20101D-01
Stage-2 Tank Top, IMU Location     604    -0.11575D-04   0.79253D-01  -0.74800D-01   0.10612D-04   0.18972D-01   0.20101D-01
Stage-2 Tank Top, IMU Location     604    -0.11575D-04   0.79253D-01  -0.74800D-01   0.10612D-04   0.18972D-01   0.20101D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     601    -0.11562D-04   0.74778D-01  -0.70576D-01   0.10604D-04   0.19158D-01   0.20298D-01
LH2 Slosh Mass Locat.              600    -0.10403D-04  -0.53705D-01   0.50688D-01   0.94225D-05   0.21889D-01   0.23192D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.12237D-04  -0.46237D+00   0.43639D+00   0.12785D-04  -0.55818D-01  -0.59141D-01

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    142.46       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.14456D-04   0.28909D-02  -0.30862D-02  -0.97034D+00   0.95966D-02   0.85656D-03
Stage-2 Gimbal                   10408    -0.14456D-04   0.28909D-02  -0.30862D-02  -0.97034D+00   0.95966D-02   0.85656D-03
Stage-2 Gimbal                   10408    -0.14456D-04   0.28909D-02  -0.30862D-02  -0.97034D+00   0.95966D-02   0.85656D-03
Stage-2 Gimbal                   10408    -0.14456D-04   0.28909D-02  -0.30862D-02  -0.97034D+00   0.95966D-02   0.85656D-03
Stage-2 Gimbal                   10408    -0.14456D-04   0.28909D-02  -0.30862D-02  -0.97034D+00   0.95966D-02   0.85656D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.35987D-05  -0.33581D-02  -0.29285D-03   0.36629D-02   0.12079D-03  -0.87541D-03
Stage-2 Tank Top, IMU Location     604     0.35987D-05  -0.33581D-02  -0.29285D-03   0.36629D-02   0.12079D-03  -0.87541D-03
Stage-2 Tank Top, IMU Location     604     0.35987D-05  -0.33581D-02  -0.29285D-03   0.36629D-02   0.12079D-03  -0.87541D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     601     0.35944D-05  -0.31617D-02  -0.26598D-03   0.36600D-02   0.12186D-03  -0.88352D-03
LH2 Slosh Mass Locat.              600     0.32160D-05   0.24313D-02   0.43770D-03   0.32315D-02   0.14002D-03  -0.99494D-03

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.38153D-05   0.19012D-01   0.23741D-02   0.44579D-02  -0.30505D-03   0.24809D-02

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    255.65       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.67862D+00  -0.68255D-01  -0.77949D-01   0.95495D-03  -0.70186D-01   0.52548D-01
Stage-2 Gimbal                   10408     0.67862D+00  -0.68255D-01  -0.77949D-01   0.95495D-03  -0.70186D-01   0.52548D-01
Stage-2 Gimbal                   10408     0.67862D+00  -0.68255D-01  -0.77949D-01   0.95495D-03  -0.70186D-01   0.52548D-01
Stage-2 Gimbal                   10408     0.67862D+00  -0.68255D-01  -0.77949D-01   0.95495D-03  -0.70186D-01   0.52548D-01
Stage-2 Gimbal                   10408     0.67862D+00  -0.68255D-01  -0.77949D-01   0.95495D-03  -0.70186D-01   0.52548D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.33695D-01  -0.22448D-02  -0.24367D-02  -0.28370D-05   0.16438D-02  -0.15184D-02
Stage-2 Tank Top, IMU Location     604    -0.33695D-01  -0.22448D-02  -0.24367D-02  -0.28370D-05   0.16438D-02  -0.15184D-02
Stage-2 Tank Top, IMU Location     604    -0.33695D-01  -0.22448D-02  -0.24367D-02  -0.28370D-05   0.16438D-02  -0.15184D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     601    -0.33552D-01  -0.18298D-02  -0.19873D-02  -0.28255D-05   0.16421D-02  -0.15168D-02
LH2 Slosh Mass Locat.              600    -0.22111D-01   0.62953D-02   0.68161D-02  -0.16775D-05   0.13008D-02  -0.12022D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.41074D-01   0.15685D-01   0.16987D-01  -0.66235D-05  -0.33718D-02   0.31132D-02

MODE#  7/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    371.54       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.93674D-01   0.36765D+00   0.59405D+00  -0.50813D-02   0.28009D+00  -0.16022D+00
Stage-2 Gimbal                   10408     0.93674D-01   0.36765D+00   0.59405D+00  -0.50813D-02   0.28009D+00  -0.16022D+00
Stage-2 Gimbal                   10408     0.93674D-01   0.36765D+00   0.59405D+00  -0.50813D-02   0.28009D+00  -0.16022D+00
Stage-2 Gimbal                   10408     0.93674D-01   0.36765D+00   0.59405D+00  -0.50813D-02   0.28009D+00  -0.16022D+00
Stage-2 Gimbal                   10408     0.93674D-01   0.36765D+00   0.59405D+00  -0.50813D-02   0.28009D+00  -0.16022D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.42454D-02   0.22264D-02   0.30336D-02   0.54989D-05  -0.16151D-01   0.10451D-01
Stage-2 Tank Top, IMU Location     604    -0.42454D-02   0.22264D-02   0.30336D-02   0.54989D-05  -0.16151D-01   0.10451D-01
Stage-2 Tank Top, IMU Location     604    -0.42454D-02   0.22264D-02   0.30336D-02   0.54989D-05  -0.16151D-01   0.10451D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.41990D-02  -0.18830D-02  -0.33028D-02   0.55718D-05  -0.15808D-01   0.10228D-01
Fuel Slosh Mass Locat.             600    -0.11108D-02  -0.20040D-01  -0.30536D-01   0.31595D-05  -0.44184D-02   0.27901D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.67255D-02  -0.15931D+00  -0.24524D+00  -0.27732D-04   0.59478D-01  -0.38640D-01

MODE#  8/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    402.45       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.12266D-01  -0.37387D+00   0.24677D+00  -0.31993D-02   0.35185D-01   0.87157D-01
Stage-2 Gimbal                   10408    -0.12266D-01  -0.37387D+00   0.24677D+00  -0.31993D-02   0.35185D-01   0.87157D-01
Stage-2 Gimbal                   10408    -0.12266D-01  -0.37387D+00   0.24677D+00  -0.31993D-02   0.35185D-01   0.87157D-01
Stage-2 Gimbal                   10408    -0.12266D-01  -0.37387D+00   0.24677D+00  -0.31993D-02   0.35185D-01   0.87157D-01
Stage-2 Gimbal                   10408    -0.12266D-01  -0.37387D+00   0.24677D+00  -0.31993D-02   0.35185D-01   0.87157D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.53465D-03   0.10232D-01  -0.66303D-02  -0.76404D-04  -0.12274D-01  -0.19415D-01
Stage-2 Tank Top, IMU Location     604     0.53465D-03   0.10232D-01  -0.66303D-02  -0.76404D-04  -0.12274D-01  -0.19415D-01
Stage-2 Tank Top, IMU Location     604     0.53465D-03   0.10232D-01  -0.66303D-02  -0.76404D-04  -0.12274D-01  -0.19415D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.52726D-03   0.19402D-01  -0.12418D-01  -0.76915D-04  -0.11839D-01  -0.18725D-01
Fuel Slosh Mass Locat.             600     0.66888D-04  -0.23598D-02   0.16889D-02  -0.24980D-04  -0.76406D-04  -0.26874D-04

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.93573D-03   0.39406D+00  -0.24853D+00   0.18985D-03   0.62484D-01   0.99078D-01

MODE#  9/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    440.61       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.37652D-01   0.15150D+00   0.26019D+00  -0.16658D-02   0.22530D+00  -0.12688D+00
Stage-2 Gimbal                   10408     0.37652D-01   0.15150D+00   0.26019D+00  -0.16658D-02   0.22530D+00  -0.12688D+00
Stage-2 Gimbal                   10408     0.37652D-01   0.15150D+00   0.26019D+00  -0.16658D-02   0.22530D+00  -0.12688D+00
Stage-2 Gimbal                   10408     0.37652D-01   0.15150D+00   0.26019D+00  -0.16658D-02   0.22530D+00  -0.12688D+00
Stage-2 Gimbal                   10408     0.37652D-01   0.15150D+00   0.26019D+00  -0.16658D-02   0.22530D+00  -0.12688D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.17413D-02   0.19042D-01   0.30673D-01   0.35747D-04   0.11144D-01  -0.68838D-02
Stage-2 Tank Top, IMU Location     604    -0.17413D-02   0.19042D-01   0.30673D-01   0.35747D-04   0.11144D-01  -0.68838D-02
Stage-2 Tank Top, IMU Location     604    -0.17413D-02   0.19042D-01   0.30673D-01   0.35747D-04   0.11144D-01  -0.68838D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.17089D-02   0.23873D-01   0.38521D-01   0.35884D-04   0.10272D-01  -0.63479D-02
Fuel Slosh Mass Locat.             600     0.11876D-03  -0.45065D-01  -0.72829D-01   0.40687D-05  -0.75348D-02   0.45684D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.35342D-02   0.25291D+00   0.41127D+00  -0.52930D-04  -0.10746D+00   0.66082D-01

MODE# 10/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    469.54       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.15057D-01   0.41344D+00  -0.26489D+00   0.21164D-02  -0.91512D-01  -0.21282D+00
Stage-2 Gimbal                   10408     0.15057D-01   0.41344D+00  -0.26489D+00   0.21164D-02  -0.91512D-01  -0.21282D+00
Stage-2 Gimbal                   10408     0.15057D-01   0.41344D+00  -0.26489D+00   0.21164D-02  -0.91512D-01  -0.21282D+00
Stage-2 Gimbal                   10408     0.15057D-01   0.41344D+00  -0.26489D+00   0.21164D-02  -0.91512D-01  -0.21282D+00
Stage-2 Gimbal                   10408     0.15057D-01   0.41344D+00  -0.26489D+00   0.21164D-02  -0.91512D-01  -0.21282D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.68831D-03   0.30437D-01  -0.18193D-01  -0.30959D-04  -0.16117D-02  -0.27458D-02
Stage-2 Tank Top, IMU Location     604    -0.68831D-03   0.30437D-01  -0.18193D-01  -0.30959D-04  -0.16117D-02  -0.27458D-02
Stage-2 Tank Top, IMU Location     604    -0.68831D-03   0.30437D-01  -0.18193D-01  -0.30959D-04  -0.16117D-02  -0.27458D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.67206D-03   0.34597D-01  -0.20717D-01  -0.31040D-04  -0.12233D-02  -0.21091D-02
Fuel Slosh Mass Locat.             600     0.16449D-03  -0.83297D-01   0.50089D-01   0.11627D-05   0.47983D-02   0.76663D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.16012D-02   0.27231D+00  -0.16582D+00   0.34501D-04   0.44464D-01   0.73010D-01
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
