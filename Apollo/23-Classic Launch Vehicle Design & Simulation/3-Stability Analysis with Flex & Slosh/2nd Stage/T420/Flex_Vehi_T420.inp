BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Launch Vehicle systems during Second Stage
! This batch set creates state-space systems for the Flexible Launch Vehicle during 
! Second Stage, the Mixing Logic matrix and also the 2nd Stage Actuator. 
! 
Flight Vehicle   : Launch Vehicle Second Stage Analysis Model at T=420 sec         
Actuator Model   : Stage-2 Linear Actuator
Mixing Matrix    : Mixing Logic Matrix for Second Stage Vehicle at t=420 sec
!
To Matlab Format : Launch Vehicle Second Stage Analysis Model at T=420 sec          
To Matlab Format : Stage-2 Linear Actuator
To Matlab Format : Mixing Logic Matrix for Second Stage Vehicle at t=420 sec
-----------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle Second Stage Analysis Model at T=420 sec                                                 
! This is the Analysis Model of Second Stage Vehicle consisting of the main engine
! and four bi-directional RCS jets. It includes Slosh and Flexibility
!
Body Axes Output, Attitude=Rate Integral             
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   367.434       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   2329.94       18828.7       18669.7       0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   92.0988       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   9.17600       17911.9      0.100000E-05   609803.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   80.8935       80.9716      0.300000E-01 -0.165000E-01
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   5.32500     -0.710000E-01 -0.899928E-01  0.159990    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          5.07300       0.00000       0.0          -0.165100     -0.152300    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.00         90.00                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   38.5000       7.20000       7.20000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   116.800       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.421479      0.600010E-03 -0.173086E-05   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.201119E-02 -0.283267E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.223557     -0.500000E-01   0.00000       0.00000       0.00000       0.00000      0.143290E-05
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.306672     -0.803000E-01   0.00000       0.00000       0.00000      0.411819E-05   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.200000E-01   0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Main Engine#1    Gimbaling 
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   29751.7       29751.7    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   9.00000       120.000       2.60000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   84.5000       0.00000       0.00000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00        -3.50          0.00000    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Rght RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0   
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):  -90.00         0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         3.50          0.00000    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Top  RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000      -3.50    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Botm RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       3.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.0000        90.000        0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   83.00         0.00000       3.50    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438     0.00       0.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438     0.00       0.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438     0.00       0.00    

Number of Slosh Modes                                                                    :  2
LOX  Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :  119.25  3.12  3.12  0.02   0.02   91.812  0.0  0.0   
Fuel Mass (slug), Frequenc 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :  41.120  3.12  3.12  0.002  0.002  85.142  0.0  0.0  

Number of Bending Modes                                                                  :  10
Flex Modes of Vehicle Second Stage with Slosh, 20% Full Tanks
----------------------------------------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-2 Linear Actuator        
Symbol Parameter Description                    (Units)      Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.002, 0.002
Ka     Gain of Amplifier ...................... (amps/volt)   10.0    
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    60.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.0e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     1.8e+6
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.72   
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   120.0
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   3000.0    
----------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Matrix for Second Stage Vehicle at t=420 sec
! Mixing Logic Matrix for the Second Stage Vehicle
!
Kmix_t420
Launch Vehicle Second Stage Analysis Model at T=420 sec
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
                                  CREATE MATLAB DATA
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle Second Stage Analysis Model at T=420 sec 
System
Vehicle
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-2 Linear Actuator     
System
actuator
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Matrix for Second Stage Vehicle at t=420 sec
Matrix Kmix_t420
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : Stage-2 20% 
Flex Modes of Vehicle Second Stage with Slosh, 20% Full Tanks
! Flex Modes for Second Stage with Empty Tanks, from File Stage2_20%.Mod
! Sensors are at the Top of LOX Tank at Node: 604
! The Modes were selected between the TVC (Node:10408) and the IMU Locat. (Node:604)

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    58.768       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.11839D-01   0.41909D-01   0.48014D-01  -0.12356D-03   0.10086D+00  -0.98323D-01
Stage-2 Gimbal                   10408     0.11839D-01   0.41909D-01   0.48014D-01  -0.12356D-03   0.10086D+00  -0.98323D-01
Stage-2 Gimbal                   10408     0.11839D-01   0.41909D-01   0.48014D-01  -0.12356D-03   0.10086D+00  -0.98323D-01
Stage-2 Gimbal                   10408     0.11839D-01   0.41909D-01   0.48014D-01  -0.12356D-03   0.10086D+00  -0.98323D-01
Stage-2 Gimbal                   10408     0.11839D-01   0.41909D-01   0.48014D-01  -0.12356D-03   0.10086D+00  -0.98323D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.21563D-02  -0.27658D-01  -0.30086D-01  -0.18212D-05  -0.49618D-02   0.45652D-02
Stage-2 Tank Top, IMU Location     604    -0.21563D-02  -0.27658D-01  -0.30086D-01  -0.18212D-05  -0.49618D-02   0.45652D-02
Stage-2 Tank Top, IMU Location     604    -0.21563D-02  -0.27658D-01  -0.30086D-01  -0.18212D-05  -0.49618D-02   0.45652D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.21522D-02  -0.37638D-01  -0.40933D-01  -0.18191D-05  -0.47838D-02   0.44014D-02
Fuel Slosh Mass Locat.             600    -0.21272D-02  -0.59242D-01  -0.64414D-01  -0.17994D-05  -0.43286D-02   0.39821D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.21774D-02   0.11944D+00   0.12975D+00  -0.18784D-05  -0.10335D-01   0.95122D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    65.162       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.36186D-03  -0.75218D-01   0.73692D-01   0.95311D-02   0.11930D+00   0.12910D+00
Stage-2 Gimbal                   10408     0.36186D-03  -0.75218D-01   0.73692D-01   0.95311D-02   0.11930D+00   0.12910D+00
Stage-2 Gimbal                   10408     0.36186D-03  -0.75218D-01   0.73692D-01   0.95311D-02   0.11930D+00   0.12910D+00
Stage-2 Gimbal                   10408     0.36186D-03  -0.75218D-01   0.73692D-01   0.95311D-02   0.11930D+00   0.12910D+00
Stage-2 Gimbal                   10408     0.36186D-03  -0.75218D-01   0.73692D-01   0.95311D-02   0.11930D+00   0.12910D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.11115D-03   0.33145D-01  -0.30721D-01  -0.13700D-04  -0.42852D-02  -0.46291D-02
Stage-2 Tank Top, IMU Location     604     0.11115D-03   0.33145D-01  -0.30721D-01  -0.13700D-04  -0.42852D-02  -0.46291D-02
Stage-2 Tank Top, IMU Location     604     0.11115D-03   0.33145D-01  -0.30721D-01  -0.13700D-04  -0.42852D-02  -0.46291D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.11089D-03   0.43309D-01  -0.40129D-01  -0.13681D-04  -0.40758D-02  -0.44027D-02
Fuel Slosh Mass Locat.             600     0.10931D-03   0.64198D-01  -0.59466D-01  -0.13499D-04  -0.35470D-02  -0.38303D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.11250D-03  -0.13945D+00   0.12896D+00  -0.14233D-04  -0.10724D-01  -0.11593D-01

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    142.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.30070D-03  -0.42630D-02  -0.44318D-02  -0.96839D+00   0.91454D-02  -0.29303D-03
Stage-2 Gimbal                   10408     0.30070D-03  -0.42630D-02  -0.44318D-02  -0.96839D+00   0.91454D-02  -0.29303D-03
Stage-2 Gimbal                   10408     0.30070D-03  -0.42630D-02  -0.44318D-02  -0.96839D+00   0.91454D-02  -0.29303D-03
Stage-2 Gimbal                   10408     0.30070D-03  -0.42630D-02  -0.44318D-02  -0.96839D+00   0.91454D-02  -0.29303D-03
Stage-2 Gimbal                   10408     0.30070D-03  -0.42630D-02  -0.44318D-02  -0.96839D+00   0.91454D-02  -0.29303D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.33464D-04   0.12252D-02   0.43568D-03   0.83604D-02  -0.47942D-05   0.19433D-03
Stage-2 Tank Top, IMU Location     604    -0.33464D-04   0.12252D-02   0.43568D-03   0.83604D-02  -0.47942D-05   0.19433D-03
Stage-2 Tank Top, IMU Location     604    -0.33464D-04   0.12252D-02   0.43568D-03   0.83604D-02  -0.47942D-05   0.19433D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.33081D-04   0.79236D-03   0.41844D-03   0.82963D-02  -0.63286D-05   0.21269D-03
Fuel Slosh Mass Locat.             600    -0.30773D-04  -0.55835D-03   0.28738D-03   0.77510D-02  -0.36488D-05   0.24798D-03

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.35489D-04  -0.48994D-02  -0.71174D-03   0.10186D-01   0.10462D-03  -0.65392D-03

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    164.37       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.16777D-01  -0.16534D+00  -0.18170D+00   0.66914D-02   0.23929D-02  -0.85309D-02
Stage-2 Gimbal                   10408     0.16777D-01  -0.16534D+00  -0.18170D+00   0.66914D-02   0.23929D-02  -0.85309D-02
Stage-2 Gimbal                   10408     0.16777D-01  -0.16534D+00  -0.18170D+00   0.66914D-02   0.23929D-02  -0.85309D-02
Stage-2 Gimbal                   10408     0.16777D-01  -0.16534D+00  -0.18170D+00   0.66914D-02   0.23929D-02  -0.85309D-02
Stage-2 Gimbal                   10408     0.16777D-01  -0.16534D+00  -0.18170D+00   0.66914D-02   0.23929D-02  -0.85309D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.19768D-02   0.11933D+00   0.12898D+00  -0.26264D-04  -0.26454D-01   0.24487D-01
Stage-2 Tank Top, IMU Location     604    -0.19768D-02   0.11933D+00   0.12898D+00  -0.26264D-04  -0.26454D-01   0.24487D-01
Stage-2 Tank Top, IMU Location     604    -0.19768D-02   0.11933D+00   0.12898D+00  -0.26264D-04  -0.26454D-01   0.24487D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.19464D-02   0.63132D-01   0.68260D-01  -0.25985D-04  -0.28103D-01   0.26014D-01
Fuel Slosh Mass Locat.             600    -0.17653D-02  -0.98046D-01  -0.10588D+00  -0.23688D-04  -0.30258D-01   0.28009D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.21380D-02  -0.44786D+00  -0.48391D+00  -0.34435D-04   0.71911D-01  -0.66553D-01

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    165.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.79259D-04   0.15426D+00  -0.14397D+00  -0.36169D-03   0.27812D-01   0.30707D-01
Stage-2 Gimbal                   10408     0.79259D-04   0.15426D+00  -0.14397D+00  -0.36169D-03   0.27812D-01   0.30707D-01
Stage-2 Gimbal                   10408     0.79259D-04   0.15426D+00  -0.14397D+00  -0.36169D-03   0.27812D-01   0.30707D-01
Stage-2 Gimbal                   10408     0.79259D-04   0.15426D+00  -0.14397D+00  -0.36169D-03   0.27812D-01   0.30707D-01
Stage-2 Gimbal                   10408     0.79259D-04   0.15426D+00  -0.14397D+00  -0.36169D-03   0.27812D-01   0.30707D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.40706D-04  -0.12842D+00   0.11872D+00   0.19471D-03  -0.24954D-01  -0.26999D-01
Stage-2 Tank Top, IMU Location     604     0.40706D-04  -0.12842D+00   0.11872D+00   0.19471D-03  -0.24954D-01  -0.26999D-01
Stage-2 Tank Top, IMU Location     604     0.40706D-04  -0.12842D+00   0.11872D+00   0.19471D-03  -0.24954D-01  -0.26999D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.40067D-04  -0.66359D-01   0.61357D-01   0.19259D-03  -0.26464D-01  -0.28631D-01
Fuel Slosh Mass Locat.             600     0.36267D-04   0.11042D+00  -0.10205D+00   0.17524D-03  -0.28374D-01  -0.30698D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.44091D-04   0.48378D+00  -0.44718D+00   0.25678D-03   0.66887D-01   0.72361D-01

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    261.13       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.66429D+00  -0.62274D-01  -0.71303D-01   0.84484D-03  -0.71278D-01   0.53592D-01
Stage-2 Gimbal                   10408     0.66429D+00  -0.62274D-01  -0.71303D-01   0.84484D-03  -0.71278D-01   0.53592D-01
Stage-2 Gimbal                   10408     0.66429D+00  -0.62274D-01  -0.71303D-01   0.84484D-03  -0.71278D-01   0.53592D-01
Stage-2 Gimbal                   10408     0.66429D+00  -0.62274D-01  -0.71303D-01   0.84484D-03  -0.71278D-01   0.53592D-01
Stage-2 Gimbal                   10408     0.66429D+00  -0.62274D-01  -0.71303D-01   0.84484D-03  -0.71278D-01   0.53592D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.61741D-01  -0.32231D-02  -0.35040D-02  -0.60180D-05   0.24046D-02  -0.22205D-02
Stage-2 Tank Top, IMU Location     604    -0.61741D-01  -0.32231D-02  -0.35040D-02  -0.60180D-05   0.24046D-02  -0.22205D-02
Stage-2 Tank Top, IMU Location     604    -0.61741D-01  -0.32231D-02  -0.35040D-02  -0.60180D-05   0.24046D-02  -0.22205D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.59118D-01   0.24801D-02   0.26733D-02  -0.57599D-05   0.23402D-02  -0.21612D-02
Fuel Slosh Mass Locat.             600    -0.44558D-01   0.12574D-01   0.13613D-01  -0.42305D-05   0.19530D-02  -0.18047D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.75963D-01   0.22971D-01   0.24892D-01  -0.14906D-04  -0.50065D-02   0.46200D-02

MODE#  7/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    380.59       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.93895D-01  -0.36469D+00  -0.59449D+00   0.49308D-02  -0.30514D+00   0.17424D+00
Stage-2 Gimbal                   10408    -0.93895D-01  -0.36469D+00  -0.59449D+00   0.49308D-02  -0.30514D+00   0.17424D+00
Stage-2 Gimbal                   10408    -0.93895D-01  -0.36469D+00  -0.59449D+00   0.49308D-02  -0.30514D+00   0.17424D+00
Stage-2 Gimbal                   10408    -0.93895D-01  -0.36469D+00  -0.59449D+00   0.49308D-02  -0.30514D+00   0.17424D+00
Stage-2 Gimbal                   10408    -0.93895D-01  -0.36469D+00  -0.59449D+00   0.49308D-02  -0.30514D+00   0.17424D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.69904D-02   0.79769D-02   0.12881D-01  -0.38332D-04   0.15703D-01  -0.10137D-01
Stage-2 Tank Top, IMU Location     604     0.69904D-02   0.79769D-02   0.12881D-01  -0.38332D-04   0.15703D-01  -0.10137D-01
Stage-2 Tank Top, IMU Location     604     0.69904D-02   0.79769D-02   0.12881D-01  -0.38332D-04   0.15703D-01  -0.10137D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.62168D-02   0.41699D-01   0.64954D-01  -0.41940D-04   0.12148D-01  -0.78209D-02
Fuel Slosh Mass Locat.             600     0.25231D-02   0.29567D-01   0.45667D-01  -0.36860D-04   0.26789D-02  -0.16079D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.11383D-01   0.14426D+00   0.22210D+00   0.14946D-03  -0.54286D-01   0.35264D-01

MODE#  8/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    421.60       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408    -0.15711D-01  -0.46487D+00   0.30496D+00  -0.35245D-02   0.58810D-01   0.13967D+00
Stage-2 Gimbal                   10408    -0.15711D-01  -0.46487D+00   0.30496D+00  -0.35245D-02   0.58810D-01   0.13967D+00
Stage-2 Gimbal                   10408    -0.15711D-01  -0.46487D+00   0.30496D+00  -0.35245D-02   0.58810D-01   0.13967D+00
Stage-2 Gimbal                   10408    -0.15711D-01  -0.46487D+00   0.30496D+00  -0.35245D-02   0.58810D-01   0.13967D+00
Stage-2 Gimbal                   10408    -0.15711D-01  -0.46487D+00   0.30496D+00  -0.35245D-02   0.58810D-01   0.13967D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604     0.10579D-02   0.34223D-01  -0.21538D-01  -0.15137D-03  -0.92432D-02  -0.14822D-01
Stage-2 Tank Top, IMU Location     604     0.10579D-02   0.34223D-01  -0.21538D-01  -0.15137D-03  -0.92432D-02  -0.14822D-01
Stage-2 Tank Top, IMU Location     604     0.10579D-02   0.34223D-01  -0.21538D-01  -0.15137D-03  -0.92432D-02  -0.14822D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601     0.89766D-03   0.93325D-01  -0.58260D-01  -0.15786D-03  -0.54222D-02  -0.86497D-02
Fuel Slosh Mass Locat.             600     0.18852D-03  -0.35898D-02   0.22735D-02  -0.10974D-03   0.35086D-02   0.58556D-02

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017     0.19865D-02   0.30411D+00  -0.18853D+00   0.28211D-03   0.48220D-01   0.77785D-01

MODE#  9/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    512.69       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.28863D-01   0.99781D-01   0.18719D+00  -0.71732D-03   0.28111D+00  -0.15154D+00
Stage-2 Gimbal                   10408     0.28863D-01   0.99781D-01   0.18719D+00  -0.71732D-03   0.28111D+00  -0.15154D+00
Stage-2 Gimbal                   10408     0.28863D-01   0.99781D-01   0.18719D+00  -0.71732D-03   0.28111D+00  -0.15154D+00
Stage-2 Gimbal                   10408     0.28863D-01   0.99781D-01   0.18719D+00  -0.71732D-03   0.28111D+00  -0.15154D+00
Stage-2 Gimbal                   10408     0.28863D-01   0.99781D-01   0.18719D+00  -0.71732D-03   0.28111D+00  -0.15154D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.17646D-02   0.51414D-01   0.88675D-01   0.14749D-03  -0.26497D-02   0.14929D-02
Stage-2 Tank Top, IMU Location     604    -0.17646D-02   0.51414D-01   0.88675D-01   0.14749D-03  -0.26497D-02   0.14929D-02
Stage-2 Tank Top, IMU Location     604    -0.17646D-02   0.51414D-01   0.88675D-01   0.14749D-03  -0.26497D-02   0.14929D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.11842D-02   0.67534D-01   0.11650D+00   0.14856D-03  -0.13610D-01   0.78184D-02
Fuel Slosh Mass Locat.             600     0.83500D-03  -0.11059D+00  -0.19109D+00   0.62602D-04  -0.32357D-01   0.18590D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.53214D-02   0.24529D+00   0.42474D+00  -0.11781D-03  -0.11771D+00   0.67975D-01

MODE# 10/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    536.18       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Stage-2 Gimbal                   10408     0.11787D-01   0.25311D+00  -0.15614D+00   0.20858D-03  -0.10466D+00  -0.25174D+00
Stage-2 Gimbal                   10408     0.11787D-01   0.25311D+00  -0.15614D+00   0.20858D-03  -0.10466D+00  -0.25174D+00
Stage-2 Gimbal                   10408     0.11787D-01   0.25311D+00  -0.15614D+00   0.20858D-03  -0.10466D+00  -0.25174D+00
Stage-2 Gimbal                   10408     0.11787D-01   0.25311D+00  -0.15614D+00   0.20858D-03  -0.10466D+00  -0.25174D+00
Stage-2 Gimbal                   10408     0.11787D-01   0.25311D+00  -0.15614D+00   0.20858D-03  -0.10466D+00  -0.25174D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Location     604    -0.66571D-03   0.85315D-01  -0.48397D-01  -0.28921D-03   0.42948D-02   0.74227D-02
Stage-2 Tank Top, IMU Location     604    -0.66571D-03   0.85315D-01  -0.48397D-01  -0.28921D-03   0.42948D-02   0.74227D-02
Stage-2 Tank Top, IMU Location     604    -0.66571D-03   0.85315D-01  -0.48397D-01  -0.28921D-03   0.42948D-02   0.74227D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass                    601    -0.38562D-03   0.95238D-01  -0.53988D-01  -0.28962D-03   0.98550D-02   0.17150D-01
Fuel Slosh Mass Locat.             600     0.50808D-03  -0.19777D+00   0.11245D+00  -0.10206D-03   0.18415D-01   0.31991D-01

                              Node ID#     Modal Data at the Disturbance Point 
Tip of Payload                   90017    -0.24113D-02   0.37470D+00  -0.21390D+00   0.19855D-03   0.60324D-01   0.10567D+00
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
