S1 Engine No:3 -Y-Z               1153    -0.25560D-02   0.27236D-03   0.85867D-02   0.49964D-05   0.10404D-02  -0.19697D-04
S1 Engine No:4 -Y-Z               1154    -0.11119D-02   0.26990D-03   0.85818D-02  -0.56899D-06   0.10583D-02  -0.18710D-04
S1 Engine No:5 -Y+Z               1155     0.98598D-03   0.27374D-03   0.85817D-02  -0.42271D-06   0.10588D-02  -0.24480D-04
S1 Engine No:6 -Y+Z               1156     0.24919D-02   0.27071D-03   0.85873D-02   0.54546D-05   0.10405D-02  -0.24622D-04
S1 Engine No:7 +Y+Z               1157     0.25360D-02   0.27110D-03   0.85881D-02  -0.46181D-05   0.10400D-02  -0.19768D-04
S1 Engine No:8 +Y+Z               1158     0.10923D-02   0.26916D-03   0.85836D-02   0.11253D-05   0.10583D-02  -0.18611D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01  -0.89614D-06  -0.14921D-01   0.26010D-03
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01  -0.89614D-06  -0.14921D-01   0.26010D-03
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01  -0.89614D-06  -0.14921D-01   0.26010D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.45497D-05  -0.10555D-02  -0.62061D-01  -0.24227D-06   0.31890D-02  -0.57407D-04
Fuel Slosh Mass Locat.             600    -0.58588D-05   0.18085D-04   0.56575D-02   0.29372D-06  -0.14039D-02   0.25016D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.22007D-04  -0.35657D-03   0.17478D-01  -0.21676D-03   0.74215D-02   0.41430D-03

MODE# 15/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.71213D-03   0.23185D-01  -0.19308D-02  -0.34428D-04   0.37868D-04   0.11625D-03
S1 Engine No:2 +Y-Z               1152    -0.71683D-03   0.23146D-01  -0.18986D-02  -0.14257D-04   0.52560D-04   0.43510D-05
S1 Engine No:3 -Y-Z               1153    -0.76069D-03   0.23147D-01  -0.18796D-02  -0.17138D-04  -0.24212D-04  -0.63103D-05
S1 Engine No:4 -Y-Z               1154    -0.76744D-03   0.23186D-01  -0.18456D-02  -0.32970D-04  -0.34543D-04   0.99049D-04
S1 Engine No:5 -Y+Z               1155    -0.77361D-03   0.23217D-01  -0.18441D-02  -0.55244D-06   0.32262D-04   0.10430D-03
S1 Engine No:6 -Y+Z               1156    -0.76727D-03   0.23229D-01  -0.18637D-02  -0.23088D-04   0.42328D-04  -0.12968D-05
S1 Engine No:7 +Y+Z               1157    -0.72221D-03   0.23229D-01  -0.19175D-02  -0.19388D-04  -0.36178D-04  -0.15797D-05
S1 Engine No:8 +Y+Z               1158    -0.71548D-03   0.23220D-01  -0.19330D-02  -0.39323D-06  -0.38087D-04   0.10992D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03  -0.33755D-04   0.19580D-03   0.23651D-02
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03  -0.33755D-04   0.19580D-03   0.23651D-02
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03  -0.33755D-04   0.19580D-03   0.23651D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.27366D-03  -0.31661D-03   0.40432D-04  -0.13052D-05  -0.77944D-04  -0.95042D-03
Fuel Slosh Mass Locat.             600    -0.75579D-03  -0.19256D-01   0.15644D-02   0.51198D-05   0.15161D-05   0.13934D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.11034D-01  -0.19873D+00   0.16150D-01  -0.85100D-02   0.12640D-01   0.15558D+00

MODE# 16/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    141.94       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.12461D-04  -0.27903D-01  -0.67393D-01  -0.28211D-01   0.25075D-04  -0.59590D-05
S1 Engine No:2 +Y-Z               1152    -0.54460D-04  -0.67347D-01  -0.27949D-01  -0.28211D-01   0.27140D-04  -0.43987D-05
S1 Engine No:3 -Y-Z               1153    -0.63286D-04  -0.67347D-01   0.27835D-01  -0.28211D-01   0.24582D-04  -0.52024D-05
S1 Engine No:4 -Y-Z               1154    -0.35623D-04  -0.27903D-01   0.67280D-01  -0.28211D-01   0.25090D-04  -0.66590D-05
S1 Engine No:5 -Y+Z               1155     0.14031D-04   0.27881D-01   0.67280D-01  -0.28211D-01   0.24944D-04  -0.31180D-05
S1 Engine No:6 -Y+Z               1156     0.55024D-04   0.67326D-01   0.27835D-01  -0.28211D-01   0.24578D-04  -0.43500D-05
S1 Engine No:7 +Y+Z               1157     0.64894D-04   0.67326D-01  -0.27949D-01  -0.28211D-01   0.27410D-04  -0.51197D-05
S1 Engine No:8 +Y+Z               1158     0.36228D-04   0.27881D-01  -0.67393D-01  -0.28211D-01   0.25169D-04  -0.41076D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05  -0.20324D-01   0.27256D-04  -0.51688D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05  -0.20324D-01   0.27256D-04  -0.51688D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05  -0.20324D-01   0.27256D-04  -0.51688D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.17548D-06  -0.25717D-04  -0.13441D-03   0.23504D-02  -0.12887D-04   0.24521D-05
Fuel Slosh Mass Locat.             600     0.11767D-05   0.49652D-04   0.26051D-03  -0.41432D-02  -0.10219D-04   0.19501D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.24483D-04   0.53017D-03   0.28636D-02  -0.37313D-01   0.20872D-02  -0.37598D-03

MODE# 17/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    142.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.18382D-02   0.19528D-04  -0.29754D-02   0.33061D-03   0.23525D-02  -0.16008D-03
S1 Engine No:2 +Y-Z               1152    -0.53760D-02   0.48403D-03  -0.34395D-02   0.33527D-03   0.24244D-02  -0.15680D-03
S1 Engine No:3 -Y-Z               1153    -0.57516D-02   0.48724D-03  -0.40936D-02   0.32672D-03   0.24304D-02  -0.22596D-03
S1 Engine No:4 -Y-Z               1154    -0.27455D-02   0.25956D-04  -0.45554D-02   0.33202D-03   0.23581D-02  -0.23428D-03
S1 Engine No:5 -Y+Z               1155     0.18775D-02  -0.63485D-03  -0.45557D-02   0.33131D-03   0.23527D-02  -0.15980D-03
S1 Engine No:6 -Y+Z               1156     0.54152D-02  -0.10961D-02  -0.40940D-02   0.32696D-03   0.24247D-02  -0.15652D-03
S1 Engine No:7 +Y+Z               1157     0.57907D-02  -0.10929D-02  -0.34388D-02   0.33521D-03   0.24306D-02  -0.22615D-03
S1 Engine No:8 +Y+Z               1158     0.27847D-02  -0.62863D-03  -0.29751D-02   0.32998D-03   0.23584D-02  -0.23467D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03   0.23040D-03   0.24800D-02  -0.20040D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03   0.23040D-03   0.24800D-02  -0.20040D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03   0.23040D-03   0.24800D-02  -0.20040D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.73494D-05  -0.10477D-02  -0.12851D-01  -0.28549D-04  -0.11730D-02   0.95112D-04
Fuel Slosh Mass Locat.             600     0.54603D-04   0.18992D-02   0.23385D-01   0.52355D-04  -0.97679D-03   0.79457D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.11485D-02   0.20580D-01   0.25313D+00  -0.48914D-02   0.18290D+00  -0.14892D-01

MODE# 18/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    152.45       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11892D-01  -0.35979D-01   0.28838D-02   0.24738D-04   0.37788D-03   0.46991D-02
S1 Engine No:2 +Y-Z               1152    -0.57499D-02  -0.35956D-01   0.28780D-02  -0.12660D-04   0.36934D-03   0.48058D-02
S1 Engine No:3 -Y-Z               1153     0.37788D-02  -0.35956D-01   0.29168D-02  -0.72998D-05   0.38884D-03   0.48064D-02
S1 Engine No:4 -Y-Z               1154     0.10999D-01  -0.35980D-01   0.29069D-02   0.21133D-04   0.40006D-03   0.46987D-02
S1 Engine No:5 -Y+Z               1155     0.11773D-01  -0.35956D-01   0.29100D-02  -0.40391D-04   0.37931D-03   0.47000D-02
S1 Engine No:6 -Y+Z               1156     0.56259D-02  -0.35918D-01   0.28909D-02   0.47176D-05   0.36520D-03   0.48073D-02
S1 Engine No:7 +Y+Z               1157    -0.39065D-02  -0.35918D-01   0.29104D-02  -0.37284D-05   0.38974D-03   0.48077D-02
S1 Engine No:8 +Y+Z               1158    -0.11126D-01  -0.35963D-01   0.28813D-02  -0.41002D-04   0.39529D-03   0.47010D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03  -0.28853D-05   0.52696D-03   0.65227D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03  -0.28853D-05   0.52696D-03   0.65227D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03  -0.28853D-05   0.52696D-03   0.65227D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.25304D-04   0.63941D-01  -0.51509D-02   0.80276D-06  -0.23174D-03  -0.28733D-02
Fuel Slosh Mass Locat.             600     0.71781D-04  -0.33165D-01   0.26740D-02  -0.21484D-05  -0.33730D-03  -0.41854D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.20684D-02  -0.17526D-02   0.16739D-03   0.14513D-02  -0.14756D-02  -0.18553D-01

MODE# 19/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    152.95       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.33807D-02   0.28071D-02   0.34733D-01  -0.64511D-05   0.42377D-02  -0.34956D-03
S1 Engine No:2 +Y-Z               1152    -0.97497D-02   0.27804D-02   0.34773D-01  -0.34105D-04   0.41262D-02  -0.35888D-03
S1 Engine No:3 -Y-Z               1153    -0.10428D-01   0.27836D-02   0.34783D-01   0.21301D-04   0.41240D-02  -0.32474D-03
S1 Engine No:4 -Y-Z               1154    -0.50081D-02   0.27831D-02   0.34766D-01  -0.14297D-04   0.42356D-02  -0.31417D-03
S1 Engine No:5 -Y+Z               1155     0.34010D-02   0.28251D-02   0.34766D-01  -0.10431D-04   0.42391D-02  -0.35015D-03
S1 Engine No:6 -Y+Z               1156     0.97690D-02   0.28181D-02   0.34787D-01   0.23611D-04   0.41261D-02  -0.35609D-03
S1 Engine No:7 +Y+Z               1157     0.10445D-01   0.28204D-02   0.34773D-01  -0.37844D-04   0.41228D-02  -0.32567D-03
S1 Engine No:8 +Y+Z               1158     0.50270D-02   0.27970D-02   0.34733D-01  -0.83634D-06   0.42360D-02  -0.31466D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02  -0.30602D-05   0.62605D-02  -0.50336D-03
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02  -0.30602D-05   0.62605D-02  -0.50336D-03
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02  -0.30602D-05   0.62605D-02  -0.50336D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.31560D-05  -0.50504D-02  -0.62643D-01   0.87187D-06  -0.27324D-02   0.22004D-03
Fuel Slosh Mass Locat.             600    -0.14945D-04   0.24073D-02   0.29884D-01  -0.23658D-05  -0.40441D-02   0.32594D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.40165D-03  -0.38802D-02  -0.47747D-01   0.18056D-02  -0.53114D-01   0.43108D-02

MODE# 20/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    210.43       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.22607D-02  -0.34961D-01   0.11248D-02   0.71316D-04  -0.17231D-03  -0.14842D-02
S1 Engine No:2 +Y-Z               1152     0.90184D-03  -0.34904D-01   0.10902D-02  -0.13807D-04  -0.19798D-03  -0.10029D-02
S1 Engine No:3 -Y-Z               1153    -0.88603D-03  -0.34904D-01   0.11653D-02  -0.84346D-05   0.14447D-03  -0.99466D-03
S1 Engine No:4 -Y-Z               1154    -0.22767D-02  -0.34962D-01   0.11283D-02   0.66210D-04   0.15280D-03  -0.14762D-02
S1 Engine No:5 -Y+Z               1155    -0.22857D-02  -0.34946D-01   0.11169D-02  -0.74880D-04  -0.16961D-03  -0.14814D-02
S1 Engine No:6 -Y+Z               1156    -0.93384D-03  -0.34894D-01   0.10898D-02   0.21516D-04  -0.20263D-03  -0.99988D-03
S1 Engine No:7 +Y+Z               1157     0.84812D-03  -0.34895D-01   0.11753D-02   0.11817D-04   0.14666D-03  -0.99304D-03
S1 Engine No:8 +Y+Z               1158     0.22393D-02  -0.34956D-01   0.11370D-02  -0.76158D-04   0.14616D-03  -0.14743D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03  -0.77153D-07   0.61160D-04   0.22748D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03  -0.77153D-07   0.61160D-04   0.22748D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03  -0.77153D-07   0.61160D-04   0.22748D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.49354D-04   0.92765D-01  -0.25208D-02   0.10276D-06   0.55102D-04   0.20428D-02
Fuel Slosh Mass Locat.             600     0.51676D-04   0.77563D-01  -0.21194D-02  -0.63973D-06   0.58211D-05   0.31410D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.85876D-03  -0.25385D-01   0.10102D-02   0.69814D-03  -0.49517D-04  -0.62779D-02

MODE# 21/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    219.71       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.42877D-01   0.20936D+00  -0.16374D-01  -0.45854D-03  -0.99936D-03  -0.15667D-01
S1 Engine No:2 +Y-Z               1152     0.20477D-01   0.20894D+00  -0.16152D-01   0.10380D-03  -0.82160D-03  -0.17623D-01
S1 Engine No:3 -Y-Z               1153    -0.15029D-01   0.20894D+00  -0.16576D-01   0.28703D-04  -0.16043D-02  -0.17688D-01
S1 Engine No:4 -Y-Z               1154    -0.41247D-01   0.20938D+00  -0.16304D-01  -0.40650D-03  -0.17881D-02  -0.15744D-01
S1 Engine No:5 -Y+Z               1155    -0.44106D-01   0.20923D+00  -0.16295D-01   0.48890D-03  -0.10383D-02  -0.15721D-01
S1 Engine No:6 -Y+Z               1156    -0.21642D-01   0.20886D+00  -0.16145D-01  -0.17940D-03  -0.80996D-03  -0.17666D-01
S1 Engine No:7 +Y+Z               1157     0.13921D-01   0.20886D+00  -0.16674D-01  -0.61996D-04  -0.16528D-02  -0.17689D-01
S1 Engine No:8 +Y+Z               1158     0.40132D-01   0.20933D+00  -0.16392D-01   0.49404D-03  -0.17413D-02  -0.15731D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03   0.54136D-06   0.66563D-04   0.85902D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03   0.54136D-06   0.66563D-04   0.85902D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03   0.54136D-06   0.66563D-04   0.85902D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.17621D-03   0.40456D-01  -0.31847D-02  -0.79880D-06   0.89116D-04   0.11442D-02
Fuel Slosh Mass Locat.             600    -0.18985D-03   0.15971D-01  -0.12709D-02   0.54620D-05   0.30512D-03   0.38983D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.57091D-02   0.13648D+00  -0.10735D-01  -0.59984D-02   0.19040D-02   0.24833D-01

MODE# 22/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    220.78       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.14260D-01  -0.16573D-01  -0.20902D+00  -0.32758D-04  -0.17359D-01   0.16324D-02
S1 Engine No:2 +Y-Z               1152     0.40052D-01  -0.16332D-01  -0.20943D+00   0.39996D-03  -0.15421D-01   0.17801D-02
S1 Engine No:3 -Y-Z               1153     0.42800D-01  -0.16331D-01  -0.20936D+00  -0.42924D-03  -0.15361D-01   0.94445D-03
S1 Engine No:4 -Y-Z               1154     0.20735D-01  -0.16167D-01  -0.20900D+00   0.12173D-03  -0.17304D-01   0.76212D-03
S1 Engine No:5 -Y+Z               1155    -0.14166D-01  -0.16626D-01  -0.20900D+00   0.61967D-04  -0.17376D-01   0.16434D-02
S1 Engine No:6 -Y+Z               1156    -0.39941D-01  -0.16372D-01  -0.20943D+00  -0.45685D-03  -0.15413D-01   0.17437D-02
S1 Engine No:7 +Y+Z               1157    -0.42651D-01  -0.16360D-01  -0.20942D+00   0.45330D-03  -0.15340D-01   0.95303D-03
S1 Engine No:8 +Y+Z               1158    -0.20618D-01  -0.16159D-01  -0.20902D+00  -0.10994D-03  -0.17303D-01   0.76452D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01   0.42724D-06   0.80926D-03  -0.64013D-04
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01   0.42724D-06   0.80926D-03  -0.64013D-04
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01   0.42724D-06   0.80926D-03  -0.64013D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.19149D-04  -0.30617D-02  -0.39352D-01  -0.58867D-06   0.11322D-02  -0.89065D-04
Fuel Slosh Mass Locat.             600     0.20949D-04  -0.10995D-02  -0.14307D-01   0.40781D-05   0.39462D-02  -0.30865D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.61726D-03  -0.83071D-02  -0.10704D+00  -0.43804D-02   0.45752D-01  -0.36334D-02

MODE# 23/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    261.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.21261D-01  -0.64181D-01   0.11109D-02   0.22396D-03   0.15100D-03   0.83526D-02
S1 Engine No:2 +Y-Z               1152    -0.92315D-02  -0.63953D-01   0.97763D-03  -0.36228D-04   0.14564D-03   0.89932D-02
S1 Engine No:3 -Y-Z               1153     0.86750D-02  -0.63954D-01   0.11677D-02  -0.23818D-04   0.14030D-03   0.89904D-02
S1 Engine No:4 -Y-Z               1154     0.21144D-01  -0.64174D-01   0.10344D-02   0.19877D-03   0.18707D-03   0.83512D-02
S1 Engine No:5 -Y+Z               1155     0.21509D-01  -0.64113D-01   0.10384D-02  -0.23106D-03   0.17051D-03   0.83764D-02
S1 Engine No:6 -Y+Z               1156     0.94428D-02  -0.63929D-01   0.96127D-03   0.91061D-04   0.13202D-03   0.90160D-02
S1 Engine No:7 +Y+Z               1157    -0.84996D-02  -0.63932D-01   0.12363D-02   0.55211D-04   0.15838D-03   0.89970D-02
S1 Engine No:8 +Y+Z               1158    -0.20963D-01  -0.64157D-01   0.11117D-02  -0.24002D-03   0.15511D-03   0.83503D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03  -0.20522D-06   0.75683D-05   0.52314D-03
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03  -0.20522D-06   0.75683D-05   0.52314D-03
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03  -0.20522D-06   0.75683D-05   0.52314D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.27790D-04   0.30279D-01  -0.51324D-03   0.48994D-06   0.60640D-04   0.40217D-02
Fuel Slosh Mass Locat.             600     0.71973D-04  -0.18694D-01   0.28561D-03  -0.47395D-05   0.56501D-05   0.19232D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.23224D-02  -0.42887D-01   0.12201D-02   0.51208D-02   0.31270D-03  -0.22892D-02

MODE# 24/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    262.16       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.85808D-02  -0.13379D-02  -0.65569D-01  -0.38444D-04  -0.89971D-02   0.17281D-03
S1 Engine No:2 +Y-Z               1152     0.21098D-01  -0.12365D-02  -0.65759D-01   0.18832D-03  -0.83521D-02   0.19936D-03
S1 Engine No:3 -Y-Z               1153     0.21434D-01  -0.12452D-02  -0.65728D-01  -0.21035D-03  -0.83532D-02   0.13391D-03
S1 Engine No:4 -Y-Z               1154     0.93566D-02  -0.11450D-02  -0.65532D-01   0.50437D-04  -0.90014D-02   0.12271D-03
S1 Engine No:5 -Y+Z               1155    -0.85914D-02  -0.13666D-02  -0.65531D-01   0.46493D-04  -0.90086D-02   0.17561D-03
S1 Engine No:6 -Y+Z               1156    -0.21096D-01  -0.12424D-02  -0.65754D-01  -0.23305D-03  -0.83471D-02   0.17618D-03
S1 Engine No:7 +Y+Z               1157    -0.21406D-01  -0.12447D-02  -0.65777D-01   0.21301D-03  -0.83424D-02   0.13795D-03
S1 Engine No:8 +Y+Z               1158    -0.93484D-02  -0.11329D-02  -0.65569D-01  -0.46646D-04  -0.89978D-02   0.12557D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01  -0.27002D-07  -0.40712D-03   0.92371D-05
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01  -0.27002D-07  -0.40712D-03   0.92371D-05
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01  -0.27002D-07  -0.40712D-03   0.92371D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.21490D-05   0.52645D-03   0.27395D-01  -0.37864D-06  -0.33326D-02   0.72452D-04
Fuel Slosh Mass Locat.             600     0.36531D-05  -0.32282D-03  -0.14907D-01   0.39157D-05  -0.93865D-04  -0.41989D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.10042D-03  -0.18709D-03  -0.36066D-01  -0.41880D-02   0.80472D-02  -0.50588D-03

MODE# 25/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    280.29       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.11645D-03  -0.24325D-02  -0.34631D-02  -0.17093D-02  -0.37364D-04  -0.68699D-04
S1 Engine No:2 +Y-Z               1152     0.10048D-03  -0.48268D-02  -0.10673D-02  -0.17159D-02  -0.54259D-04  -0.47520D-04
S1 Engine No:3 -Y-Z               1153     0.25556D-04  -0.48272D-02   0.23241D-02  -0.17110D-02  -0.40642D-04  -0.36446D-04
S1 Engine No:4 -Y-Z               1154    -0.74725D-04  -0.24351D-02   0.47162D-02  -0.17106D-02  -0.23587D-04  -0.57211D-04
S1 Engine No:5 -Y+Z               1155    -0.12814D-03   0.95662D-03   0.47156D-02  -0.17167D-02  -0.37336D-04  -0.68244D-04
S1 Engine No:6 -Y+Z               1156    -0.11291D-03   0.33532D-02   0.23207D-02  -0.17092D-02  -0.55572D-04  -0.47348D-04
S1 Engine No:7 +Y+Z               1157    -0.38208D-04   0.33526D-02  -0.10632D-02  -0.17147D-02  -0.40319D-04  -0.36180D-04
S1 Engine No:8 +Y+Z               1158     0.61986D-04   0.95314D-03  -0.34625D-02  -0.17158D-02  -0.24132D-04  -0.56096D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03   0.37116D-04  -0.11368D-06  -0.14444D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03   0.37116D-04  -0.11368D-06  -0.14444D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03   0.37116D-04  -0.11368D-06  -0.14444D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.19587D-04  -0.17488D-03   0.12851D-03  -0.10242D-03   0.11065D-04   0.11303D-04
Fuel Slosh Mass Locat.             600    -0.28313D-04   0.31508D-03  -0.24718D-03   0.11174D-02  -0.46255D-04  -0.57086D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.61865D-03   0.61865D-02  -0.45493D-02  -0.11761D+01  -0.23862D-02  -0.36608D-02

MODE# 26/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    304.30       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.47553D-01  -0.10932D+00   0.46897D-02   0.58878D-03   0.11536D-02   0.18804D-01
S1 Engine No:2 +Y-Z               1152    -0.21913D-01  -0.10872D+00   0.43549D-02  -0.15020D-03   0.11612D-02   0.20009D-01
S1 Engine No:3 -Y-Z               1153     0.17670D-01  -0.10872D+00   0.49322D-02  -0.89892D-04   0.44773D-03   0.19967D-01
S1 Engine No:4 -Y-Z               1154     0.45640D-01  -0.10930D+00   0.45795D-02   0.49837D-03   0.64027D-03   0.18748D-01
S1 Engine No:5 -Y+Z               1155     0.47500D-01  -0.10903D+00   0.45878D-02  -0.67675D-03   0.12097D-02   0.18852D-01
S1 Engine No:6 -Y+Z               1156     0.21743D-01  -0.10849D+00   0.43529D-02   0.28170D-03   0.10935D-02   0.20083D-01
S1 Engine No:7 +Y+Z               1157    -0.17979D-01  -0.10851D+00   0.51148D-02   0.13412D-03   0.46477D-03   0.20008D-01
S1 Engine No:8 +Y+Z               1158    -0.45916D-01  -0.10919D+00   0.46959D-02  -0.69898D-03   0.51883D-03   0.18767D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03   0.14302D-06   0.30252D-05   0.39877D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03   0.14302D-06   0.30252D-05   0.39877D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03   0.14302D-06   0.30252D-05   0.39877D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.24007D-03   0.46444D-01  -0.19579D-02  -0.50350D-06   0.39479D-05   0.22093D-03
Fuel Slosh Mass Locat.             600     0.34807D-03  -0.70424D-01   0.30228D-02   0.62920D-05   0.25957D-03   0.59946D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.57454D-02  -0.73482D-01   0.35464D-02  -0.63234D-02   0.42734D-03   0.31930D-02

MODE# 27/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    304.61       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.17722D-01   0.50186D-02   0.10973D+00   0.87299D-04   0.19931D-01  -0.51650D-03
S1 Engine No:2 +Y-Z               1152    -0.45746D-01   0.46967D-02   0.11027D+00  -0.51232D-03   0.18764D-01  -0.64349D-03
S1 Engine No:3 -Y-Z               1153    -0.47493D-01   0.47206D-02   0.11021D+00   0.54569D-03   0.18799D-01  -0.11103D-02
S1 Engine No:4 -Y-Z               1154    -0.21776D-01   0.44915D-02   0.10972D+00  -0.19777D-03   0.19975D-01  -0.10923D-02
S1 Engine No:5 -Y+Z               1155     0.17797D-01   0.51568D-02   0.10972D+00  -0.15062D-03   0.19964D-01  -0.51920D-03
S1 Engine No:6 -Y+Z               1156     0.45774D-01   0.48218D-02   0.11031D+00   0.60485D-03   0.18749D-01  -0.57106D-03
S1 Engine No:7 +Y+Z               1157     0.47441D-01   0.48269D-02   0.11032D+00  -0.59462D-03   0.18764D-01  -0.11195D-02
S1 Engine No:8 +Y+Z               1158     0.21789D-01   0.44947D-02   0.10973D+00   0.13278D-03   0.19957D-01  -0.11055D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01  -0.31472D-07   0.68858D-04  -0.16626D-05
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01  -0.31472D-07   0.68858D-04  -0.16626D-05
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01  -0.31472D-07   0.68858D-04  -0.16626D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.17384D-04  -0.20086D-02  -0.45515D-01  -0.30224D-06   0.10685D-03  -0.10156D-04
Fuel Slosh Mass Locat.             600    -0.24036D-04   0.30352D-02   0.70022D-01   0.45025D-05   0.59538D-02  -0.25583D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.37796D-03   0.22556D-02   0.61055D-01  -0.46010D-02  -0.60995D-02   0.55504D-03

MODE# 28/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    356.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.39662D-01  -0.82425D-01   0.92096D-03   0.87958D-03   0.81505D-03   0.16138D-01
S1 Engine No:2 +Y-Z               1152    -0.17249D-01  -0.81516D-01   0.32697D-03  -0.18968D-03   0.91697D-03   0.17570D-01
S1 Engine No:3 -Y-Z               1153     0.17374D-01  -0.81518D-01   0.11738D-02  -0.16594D-03  -0.66239D-03   0.17560D-01
S1 Engine No:4 -Y-Z               1154     0.40318D-01  -0.82327D-01   0.64649D-03   0.72036D-03  -0.34260D-03   0.16150D-01
S1 Engine No:5 -Y+Z               1155     0.40978D-01  -0.81894D-01   0.60956D-03  -0.10195D-02   0.96790D-03   0.16298D-01
S1 Engine No:6 -Y+Z               1156     0.18347D-01  -0.81146D-01   0.26334D-03   0.51419D-03   0.87994D-03   0.17784D-01
S1 Engine No:7 +Y+Z               1157    -0.16610D-01  -0.81169D-01   0.16217D-02   0.30125D-03  -0.60150D-03   0.17634D-01
S1 Engine No:8 +Y+Z               1158    -0.39444D-01  -0.82174D-01   0.98980D-03  -0.10869D-02  -0.55811D-03   0.16091D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04   0.35855D-07   0.11136D-04   0.12010D-02
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04   0.35855D-07   0.11136D-04   0.12010D-02
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04   0.35855D-07   0.11136D-04   0.12010D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.43877D-03  -0.10410D+00   0.11331D-02  -0.85159D-07  -0.38251D-04  -0.37780D-02
Fuel Slosh Mass Locat.             600    -0.35580D-03   0.26309D-01  -0.32066D-03   0.15287D-05   0.48175D-04   0.45547D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.56774D-02  -0.55789D-01   0.11930D-02  -0.13264D-02   0.52126D-03   0.76382D-02

MODE# 29/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    357.28       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.16964D-01   0.13169D-02   0.82771D-01   0.21761D-03   0.17686D-01   0.50860D-03
S1 Engine No:2 +Y-Z               1152    -0.40262D-01   0.88439D-03   0.83499D-01  -0.73486D-03   0.16351D-01   0.33959D-03
S1 Engine No:3 -Y-Z               1153    -0.40737D-01   0.87026D-03   0.83368D-01   0.82846D-03   0.16375D-01  -0.80413D-03
S1 Engine No:4 -Y-Z               1154    -0.17948D-01   0.49007D-03   0.82650D-01  -0.33751D-03   0.17758D-01  -0.86722D-03
S1 Engine No:5 -Y+Z               1155     0.17085D-01   0.16032D-02   0.82654D-01  -0.28904D-03   0.17744D-01   0.52810D-03
S1 Engine No:6 -Y+Z               1156     0.40259D-01   0.10716D-02   0.83535D-01   0.95326D-03   0.16309D-01   0.48263D-03
S1 Engine No:7 +Y+Z               1157     0.40556D-01   0.10241D-02   0.83653D-01  -0.86422D-03   0.16307D-01  -0.79952D-03
S1 Engine No:8 +Y+Z               1158     0.17912D-01   0.46482D-03   0.82777D-01   0.18740D-03   0.17682D-01  -0.89956D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02   0.41731D-06   0.10431D-02  -0.13205D-04
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02   0.41731D-06   0.10431D-02  -0.13205D-04
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02   0.41731D-06   0.10431D-02  -0.13205D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.11734D-04   0.11156D-02   0.10343D+00  -0.14015D-06  -0.35261D-02   0.40910D-04
Fuel Slosh Mass Locat.             600     0.77455D-05  -0.25494D-03  -0.26781D-01   0.11195D-05   0.45737D-02  -0.50676D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.17659D-03  -0.92924D-04   0.46193D-01  -0.10254D-02   0.43712D-03   0.43843D-03

MODE# 30/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    385.09       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11047D-01  -0.21324D-01   0.55668D-04   0.36031D-03   0.28800D-03   0.43856D-02
S1 Engine No:2 +Y-Z               1152    -0.49949D-02  -0.20933D-01  -0.22704D-03  -0.52739D-04   0.36881D-03   0.49204D-02
S1 Engine No:3 -Y-Z               1153     0.46536D-02  -0.20930D-01   0.93653D-04  -0.69577D-04  -0.35263D-03   0.49090D-02
S1 Engine No:4 -Y-Z               1154     0.10762D-01  -0.21235D-01  -0.11571D-03   0.26863D-03  -0.20971D-03   0.43627D-02
S1 Engine No:5 -Y+Z               1155     0.10930D-01  -0.20997D-01  -0.14680D-03  -0.44308D-03   0.35806D-03   0.44246D-02
S1 Engine No:6 -Y+Z               1156     0.47474D-02  -0.20707D-01  -0.27454D-03   0.26693D-03   0.30146D-03   0.50425D-02
S1 Engine No:7 +Y+Z               1157    -0.51312D-02  -0.20721D-01   0.39218D-03   0.15346D-03  -0.39455D-03   0.49882D-02
S1 Engine No:8 +Y+Z               1158    -0.11146D-01  -0.21162D-01   0.10458D-03  -0.49544D-03  -0.36908D-03   0.43675D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05   0.43403D-08  -0.73187D-06  -0.54007D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05   0.43403D-08  -0.73187D-06  -0.54007D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05   0.43403D-08  -0.73187D-06  -0.54007D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.97973D-04   0.10435D-01  -0.54256D-05  -0.16325D-07   0.84805D-06   0.55982D-02
Fuel Slosh Mass Locat.             600     0.18657D-03   0.21205D-01  -0.55536D-05   0.30774D-06  -0.26040D-06   0.96764D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.26121D-02  -0.14420D-01   0.18524D-03  -0.24002D-03   0.13362D-03   0.27706D-02

MODE# 31/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    387.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.44295D-02   0.13012D-03   0.19339D-01   0.10343D-03   0.45479D-02   0.29044D-03
S1 Engine No:2 +Y-Z               1152    -0.10124D-01  -0.20563D-04   0.19589D-01  -0.26692D-03   0.40766D-02   0.21918D-03
S1 Engine No:3 -Y-Z               1153    -0.10181D-01  -0.40836D-04   0.19511D-01   0.32814D-03   0.40798D-02  -0.26822D-03
S1 Engine No:4 -Y-Z               1154    -0.44923D-02  -0.17739D-03   0.19252D-01  -0.16612D-03   0.45900D-02  -0.29587D-03
S1 Engine No:5 -Y+Z               1155     0.45281D-02   0.31724D-03   0.19257D-01  -0.12761D-03   0.45768D-02   0.31667D-03
S1 Engine No:6 -Y+Z               1156     0.10132D-01   0.86944D-04   0.19616D-01   0.40058D-03   0.40482D-02   0.30388D-03
S1 Engine No:7 +Y+Z               1157     0.10078D-01   0.48355D-04   0.19699D-01  -0.33577D-03   0.40391D-02  -0.25691D-03
S1 Engine No:8 +Y+Z               1158     0.44856D-02  -0.20241D-03   0.19345D-01   0.55380D-04   0.45271D-02  -0.32197D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01  -0.80190D-06  -0.54805D-02   0.64608D-06
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01  -0.80190D-06  -0.54805D-02   0.64608D-06
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01  -0.80190D-06  -0.54805D-02   0.64608D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.12099D-05   0.18069D-05  -0.13285D-01   0.47988D-06   0.55703D-02  -0.58072D-06
Fuel Slosh Mass Locat.             600     0.76400D-08   0.12270D-06  -0.20039D-01   0.17845D-06   0.86924D-03  -0.43739D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.36615D-04  -0.16884D-03   0.10598D-01  -0.16577D-03   0.70021D-03   0.12361D-03
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
