BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=10 sec
! This batch set creates dynamic models for Control Analysis at T=10 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
! --------------   Create Vehicle, TVC and Actuator Models  ------------
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=10.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=10.0 sec 
Actuator Model   : Stage-1 Linear Actuator
System Connection: System of 8 TVC Actuators
!
! --------------   Build the Flight Control System  ---------------------
Transf-Function  : Integrator
Transf-Function  : Alpha Estimator
Transf-Function  : Beta Estimator
Transf-Function  : Low Pass Filters
System Connection: Flight Control System 
!
!  -------------   Create Plant Models  ---------------------------------
System Connection: Plant Model at T=10 sec, Vehicle/ Actuators
System Connection: Closed-Loop System
System Connection: Open-Loop System
System Connection: Roll Loop Opened, Others Closed
System Connection: Pitch Loop Opened, Others Closed
System Connection: Yaw Loop Opened, Others Closed
!
!  -------------   Export to Matlab  -----------------------------------
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=10.0 sec            
To Matlab Format : Plant Model at T=10 sec, Vehicle/ Actuators
To Matlab Format : Mixing Logic for First Stage Model, at T=10.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
To Matlab Format : Flight Control System
To Matlab Format : Closed-Loop System
To Matlab Format : Open-Loop System
To Matlab Format : Roll Loop Opened, Others Closed
To Matlab Format : Pitch Loop Opened, Others Closed
To Matlab Format : Yaw Loop Opened, Others Closed
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=10.0 sec                                       
! This is a Launch Vehicle Control Analysis Model at t=10 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 100% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.012 .
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   5070.0        32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   36805.3      0.281044E+07  0.280948E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   57.8656       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.071         79.6400       7.38000       384.843    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   8.8           40.88         0.0          -0.001
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.54          0.0          -0.09          0.000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           89.67         0.00000       0.0           0.001        -0.0
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.00         90.00                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.415        7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.4405       -0.00081       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  -0.0          -0.03557       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.0061       -0.03557       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.27          0.1114        0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          -0.1114        0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945       -1.0332     
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332       -2.4945 
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332       -2.4945
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945       -1.0332 
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945        1.0332
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332        2.4945
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332        2.4945
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945        1.0332 

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438    0.000      0.000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438    0.000      0.000    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438    0.000      0.000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000       

Number of Slosh Modes                                                                    :  2
LOX Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   121.51   3.11   3.11   0.005  0.005  71.09   0.0  0.0   
LH2 Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   41.906   3.11   3.11   0.001  0.001  41.16   0.0  0.0 

Number of Bending Modes                                                                  : 31
First Stage Flex Modes at 100% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=10.0 sec 
! Thrust Vector Control Matrix at t=10 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=10.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
System of 8 TVC Actuators
! Combination of 8 TVC Actuators in Parallel
Titles of Systems to be Combined
Title 1 Stage-1 Linear Actuator 
Title 2 Stage-1 Linear Actuator 
Title 3 Stage-1 Linear Actuator 
Title 4 Stage-1 Linear Actuator 
Title 5 Stage-1 Linear Actuator 
Title 6 Stage-1 Linear Actuator 
Title 7 Stage-1 Linear Actuator 
Title 8 Stage-1 Linear Actuator 
SYSTEM INPUTS TO SUBSYSTEM  1                                                           Engine # 1
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                Command Input
System Input  9 to Subsystem  1, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                           Engine # 2
System Input  2 to Subsystem  2, Input  1, Gain= 1.00000                                Command Input
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                           Engine # 3
System Input  3 to Subsystem  3, Input  1, Gain= 1.00000                                Command Input
System Input 11 to Subsystem  3, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                           Engine # 4
System Input  4 to Subsystem  4, Input  1, Gain= 1.00000                                Command Input
System Input 12 to Subsystem  4, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                           Engine # 5
System Input  5 to Subsystem  5, Input  1, Gain= 1.00000                                Command Input
System Input 13 to Subsystem  5, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  6                                                           Engine # 6
System Input  6 to Subsystem  6, Input  1, Gain= 1.00000                                Command Input
System Input 14 to Subsystem  6, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  7                                                           Engine # 7
System Input  7 to Subsystem  7, Input  1, Gain= 1.00000                                Command Input
System Input 15 to Subsystem  7, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  8                                                           Engine # 8
System Input  8 to Subsystem  8, Input  1, Gain= 1.00000                                Command Input
System Input 16 to Subsystem  8, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                        Engine # 1
System Output  1 from Subsystem  1, Output  1, Gain= 1.00000                            Deflection
System Output  9 from Subsystem  1, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                        Engine # 2
System Output  2 from Subsystem  2, Output  1, Gain= 1.00000                            Deflection
System Output 10 from Subsystem  2, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                        Engine # 3
System Output  3 from Subsystem  3, Output  1, Gain= 1.00000                            Deflection
System Output 11 from Subsystem  3, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                        Engine # 4
System Output  4 from Subsystem  4, Output  1, Gain= 1.00000                            Deflection
System Output 12 from Subsystem  4, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5                                                        Engine # 5
System Output  5 from Subsystem  5, Output  1, Gain= 1.00000                            Deflection
System Output 13 from Subsystem  5, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  6                                                        Engine # 6
System Output  6 from Subsystem  6, Output  1, Gain= 1.00000                            Deflection
System Output 14 from Subsystem  6, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  7                                                        Engine # 7
System Output  7 from Subsystem  7, Output  1, Gain= 1.00000                            Deflection
System Output 15 from Subsystem  7, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  8                                                        Engine # 8
System Output  8 from Subsystem  8, Output  1, Gain= 1.00000                            Deflection
System Output 16 from Subsystem  8, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
Definitions of Inputs  =  16
Engine # 1 delta command (rad)   
Engine # 2 delta command (rad)                                                              
Engine # 3 delta command (rad)                                                              
Engine # 4 delta command (rad)                                                              
Engine # 5 delta command (rad)                                                              
Engine # 6 delta command (rad)                                                              
Engine # 7 delta command (rad)                                                              
Engine # 8 delta command (rad)                                                              
Engine # 1 Load-Torque (ft-lb)    
Engine # 2 Load-Torque (ft-lb)    
Engine # 3 Load-Torque (ft-lb)    
Engine # 4 Load-Torque (ft-lb)    
Engine # 5 Load-Torque (ft-lb)    
Engine # 6 Load-Torque (ft-lb)    
Engine # 7 Load-Torque (ft-lb)    
Engine # 8 Load-Torque (ft-lb)    
 
Definitions of Outputs =  16
Engine # 1 deflection (rad)   
Engine # 2 deflection (rad)   
Engine # 3 deflection (rad)   
Engine # 4 deflection (rad)   
Engine # 5 deflection (rad)   
Engine # 6 deflection (rad)   
Engine # 7 deflection (rad)   
Engine # 8 deflection (rad)   
Engine # 1 accelerat. (rad/sec^2)   
Engine # 2 accelerat. (rad/sec^2)   
Engine # 3 accelerat. (rad/sec^2)   
Engine # 4 accelerat. (rad/sec^2)   
Engine # 5 accelerat. (rad/sec^2)   
Engine # 6 accelerat. (rad/sec^2)   
Engine # 7 accelerat. (rad/sec^2)   
Engine # 8 accelerat. (rad/sec^2)   
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Plant Model at T=10 sec, Vehicle/ Actuators
! Combines the Vehicle with the 8 Pitch and 8 Yaw Actuators
!
Titles of Systems to be Combined
Title 1 Launch Vehicle First Stage Analysis Model, T=10.0 sec                                                    
Title 2 System of 8 TVC Actuators              
Title 3 System of 8 TVC Actuators           
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   To Pitch Actuators (1-8)
System Input  1 to Subsystem  2, Input  1, Gain= 1.00000            
System Input  2 to Subsystem  2, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  2, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  2, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  2, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  2, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  2, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  2, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   To Yaw Actuators (1-8)
System Input  9 to Subsystem  3, Input  1, Gain= 1.00000            
System Input 10 to Subsystem  3, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  3, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  3, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  3, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  3, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  3, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  3, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  1                                                                  
System Input 17 to Subsystem  1, Input 33, Gain= 1.0                                            Wind-Gust
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                         Pitch Actuat to Vehicle 
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                    delta_y1  Pitch Engine Deflects  
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                    delta_y2
Subsystem  2, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                    delta_y3
Subsystem  2, Output  4 to Subsystem  1, Input  4, Gain= 1.0                                    delta_y4
Subsystem  2, Output  5 to Subsystem  1, Input  5, Gain= 1.0                                    delta_y5
Subsystem  2, Output  6 to Subsystem  1, Input  6, Gain= 1.0                                    delta_y6
Subsystem  2, Output  7 to Subsystem  1, Input  7, Gain= 1.0                                    delta_y7
Subsystem  2, Output  8 to Subsystem  1, Input  8, Gain= 1.0                                    delta_y8
Subsystem  2, Output  9 to Subsystem  1, Input  9, Gain= 1.0                                    dy1_dd    Engine Accels
Subsystem  2, Output 10 to Subsystem  1, Input 10, Gain= 1.0                                    dy2_dd
Subsystem  2, Output 11 to Subsystem  1, Input 11, Gain= 1.0                                    dy3_dd
Subsystem  2, Output 12 to Subsystem  1, Input 12, Gain= 1.0                                    dy4_dd
Subsystem  2, Output 13 to Subsystem  1, Input 13, Gain= 1.0                                    dy5_dd
Subsystem  2, Output 14 to Subsystem  1, Input 14, Gain= 1.0                                    dy6_dd
Subsystem  2, Output 15 to Subsystem  1, Input 15, Gain= 1.0                                    dy7_dd
Subsystem  2, Output 16 to Subsystem  1, Input 16, Gain= 1.0                                    dy8_dd
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                                                         Yaw Actuat to Vehicle 
Subsystem  3, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                    delta_z1  Yaw Engine Deflects
Subsystem  3, Output  2 to Subsystem  1, Input 18, Gain= 1.0                                    delta_z2
Subsystem  3, Output  3 to Subsystem  1, Input 19, Gain= 1.0                                    delta_z3
Subsystem  3, Output  4 to Subsystem  1, Input 20, Gain= 1.0                                    delta_z4
Subsystem  3, Output  5 to Subsystem  1, Input 21, Gain= 1.0                                    delta_z5
Subsystem  3, Output  6 to Subsystem  1, Input 22, Gain= 1.0                                    delta_z6
Subsystem  3, Output  7 to Subsystem  1, Input 23, Gain= 1.0                                    delta_z7
Subsystem  3, Output  8 to Subsystem  1, Input 24, Gain= 1.0                                    delta_z8
Subsystem  3, Output  9 to Subsystem  1, Input 25, Gain= 1.0                                    dz1_dd    Yaw Engine Accels
Subsystem  3, Output 10 to Subsystem  1, Input 26, Gain= 1.0                                    dz2_dd
Subsystem  3, Output 11 to Subsystem  1, Input 27, Gain= 1.0                                    dz3_dd
Subsystem  3, Output 12 to Subsystem  1, Input 28, Gain= 1.0                                    dz4_dd
Subsystem  3, Output 13 to Subsystem  1, Input 29, Gain= 1.0                                    dz5_dd
Subsystem  3, Output 14 to Subsystem  1, Input 30, Gain= 1.0                                    dz6_dd
Subsystem  3, Output 15 to Subsystem  1, Input 31, Gain= 1.0                                    dz7_dd
Subsystem  3, Output 16 to Subsystem  1, Input 32, Gain= 1.0                                    dz8_dd
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                         Load-Torq TLY to Pitch Actuat 
Subsystem  1, Output 17 to Subsystem  2, Input  9, Gain= 1.0                                    TL_y1
Subsystem  1, Output 18 to Subsystem  2, Input 10, Gain= 1.0                                    TL_y2
Subsystem  1, Output 19 to Subsystem  2, Input 11, Gain= 1.0                                    TL_y3
Subsystem  1, Output 20 to Subsystem  2, Input 12, Gain= 1.0                                    TL_y4
Subsystem  1, Output 21 to Subsystem  2, Input 13, Gain= 1.0                                    TL_y5
Subsystem  1, Output 22 to Subsystem  2, Input 14, Gain= 1.0                                    TL_y6
Subsystem  1, Output 23 to Subsystem  2, Input 15, Gain= 1.0                                    TL_y7
Subsystem  1, Output 24 to Subsystem  2, Input 16, Gain= 1.0                                    TL_y8
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Load-Torq TLZ to Yaw Actuators
Subsystem  1, Output 25 to Subsystem  3, Input  9, Gain= 1.0                                    TL_z1
Subsystem  1, Output 26 to Subsystem  3, Input 10, Gain= 1.0                                    TL_z2
Subsystem  1, Output 27 to Subsystem  3, Input 11, Gain= 1.0                                    TL_z3
Subsystem  1, Output 28 to Subsystem  3, Input 12, Gain= 1.0                                    TL_z4
Subsystem  1, Output 29 to Subsystem  3, Input 13, Gain= 1.0                                    TL_z5
Subsystem  1, Output 30 to Subsystem  3, Input 14, Gain= 1.0                                    TL_z6
Subsystem  1, Output 31 to Subsystem  3, Input 15, Gain= 1.0                                    TL_z7
Subsystem  1, Output 32 to Subsystem  3, Input 16, Gain= 1.0                                    TL_z8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                Vehicle Outputs
Via Matrix +I16                                                                     
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                Pitch Gimbal Deflects
System Output 17 from Subsystem  2, Output  1, Gain= 1.0                                        dy-1
System Output 18 from Subsystem  2, Output  2, Gain= 1.0                                        dy-2
System Output 19 from Subsystem  2, Output  3, Gain= 1.0                                        dy-3
System Output 20 from Subsystem  2, Output  4, Gain= 1.0                                        dy-4
System Output 21 from Subsystem  2, Output  5, Gain= 1.0                                        dy-5
System Output 22 from Subsystem  2, Output  6, Gain= 1.0                                        dy-6
System Output 23 from Subsystem  2, Output  7, Gain= 1.0                                        dy-7
System Output 24 from Subsystem  2, Output  8, Gain= 1.0                                        dy-8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                Yaw Gimbal Deflects
System Output 25 from Subsystem  3, Output  1, Gain= 1.0                                        dz-1
System Output 26 from Subsystem  3, Output  2, Gain= 1.0                                        dz-2
System Output 27 from Subsystem  3, Output  3, Gain= 1.0                                        dz-3
System Output 28 from Subsystem  3, Output  4, Gain= 1.0                                        dz-4
System Output 29 from Subsystem  3, Output  5, Gain= 1.0                                        dz-5
System Output 30 from Subsystem  3, Output  6, Gain= 1.0                                        dz-6
System Output 31 from Subsystem  3, Output  7, Gain= 1.0                                        dz-7
System Output 32 from Subsystem  3, Output  8, Gain= 1.0                                        dz-8
..............................................................................
Definitions of Inputs  =  17
Engine Pitch Deflect Comd delta y_1 (rad)   
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)   
Wind-Gust Velocity (ft/sec)
 
Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Alpha Estimator
Continuous
TF. Block #  1 Nz-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Alfa Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at (Dummy)                             Order of Numer, Denom=  2  2
Numer 1.0         1.0         13.0
Denom 1.0         1.0         13.0
......................................................
Block #, from Input #, Gain
 2       1    -22803.0                                           Eng #1 Dy
 2       2    -22803.0                                           Eng #2 Dy
 2       3    -22803.0                                           Eng #3 Dy
 2       4    -22803.0                                           Eng #4 Dy
 2       5    -22803.0                                           Eng #5 Dy
 2       6    -22803.0                                           Eng #6 Dy
 2       7    -22803.0                                           Eng #7 Dy
 2       8    -22803.0                                           Eng #8 Dy
 1       9     15.0                                              Pitch Rate q
 2      10    -5070.0                                            Zdd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    -5070.0                                            Vehi Mass
 2       3    -11.5                                              Qbar.Sref.Cza
 3       2     0.002                                             Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (deg2rad)
............................
Definitions of Inputs  =  10
Engine # 1 DY Deflection in (rad)
Engine # 2 DY Deflection in (rad)
Engine # 3 DY Deflection in (rad)
Engine # 4 DY Deflection in (rad)
Engine # 5 DY Deflection in (rad)
Engine # 6 DY Deflection in (rad)
Engine # 7 DY Deflection in (rad)
Engine # 8 DY Deflection in (rad)
Vehicle Pitch Rate      (rad/sec)                                            
Normal  Accelerat. Nz (ft/sec^2)                                                
 
Definitions of Outputs =   1
Alpha Estimate in (rad)
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Beta Estimator
Continuous
TF. Block #  1 Ny-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Beta Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at (Dummy)                             Order of Numer, Denom=  2  2
Numer 1.0         1.0         13.0
Denom 1.0         1.0         13.0
......................................................
Block #, from Input #, Gain
 2       1     22803.0                                           Eng #1 Dz
 2       2     22803.0                                           Eng #2 Dz
 2       3     22803.0                                           Eng #3 Dz
 2       4     22803.0                                           Eng #4 Dz
 2       5     22803.0                                           Eng #5 Dz
 2       6     22803.0                                           Eng #6 Dz
 2       7     22803.0                                           Eng #7 Dz
 2       8     22803.0                                           Eng #8 Dz
 1       9     15.0                                              Yaw Rate r
 2      10    -5070.0                                            Ydd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    +5070.0                                            Vehi Mass
 2       3    -11.5                                              Qbar.Sref.Cyb
 3       2     0.002                                             Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (deg2rad)
............................
Definitions of Inputs  =  10
Engine # 1 DZ Deflection in (rad)
Engine # 2 DZ Deflection in (rad)
Engine # 3 DZ Deflection in (rad)
Engine # 4 DZ Deflection in (rad)
Engine # 5 DZ Deflection in (rad)
Engine # 6 DZ Deflection in (rad)
Engine # 7 DZ Deflection in (rad)
Engine # 8 DZ Deflection in (rad)
Vehicle Yaw Rate      (rad/sec)                                            
Lateral Accelerat. Ny (ft/sec^2)                                                
 
Definitions of Outputs =   1
Beta Estimate in (rad)
---------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Integrator
Continuous
TF. Block #  1    1/s                                            Order of Numer, Denom=  0  1
Numer 0.0         1.0      
Denom 1.0         0.0      
......................................................
Block #, from Input #, Gain
  1  1    1.0                             
...........................
Outpt #, from Block #, Gain
  1  1    1.0
...........................
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Low Pass Filters
Continuous
TF. Block #  1 Roll Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         900.0
Denom 1.0         39.0        900.0
TF. Block #  2 Ptch Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         289.0
Denom 1.0         22.5        289.0
TF. Block #  3 Yaw Low-Pass                                      Order of Numer, Denom=  0  2
Numer 0.0         0.0         289.0
Denom 1.0         22.5        289.0
TF. Block #  4 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  5 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  6 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
......................................................
Block #, from Input #, Gain
 1       1        1.0                                            
 2       2        1.0                                            
 3       3        1.0                                            
...........................
Block #, from Block #, Gain
 4       1        1.0                                 
 5       2        1.0                                 
 6       3        1.0                                 
............................
Outpt #, from Block #, Gain
 1       4        1.0                                            DP_TVC
 2       5        1.0                                            DQ_TVC
 3       6        1.0                                            DR_TVC
............................
Definitions of Inputs  =   3
Roll   Filter Input
Pitch  Filter Input
Yaw    Filter Input
 
Definitions of Outputs =   3
Roll   Filter Output DP_tvc
Pitch  Filter Output DQ_tvc
Yaw    Filter Output DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Flight Control System
! Combine the Filters, Gains and Alpha/Beta Estimators. The Controller
! in Pitch  uses state-feedback from: [Theta, q, Alpha, Theta_Integral]
! in Yaw it uses state-feedback from: [Psi,   r, Beta,  & Psi_Integral]
!
Titles of Systems to be Combined
Title 1 Alpha Estimator
Title 2 Beta Estimator
Title 3 Low Pass Filters
Title 4 Integrator
Title 5 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                                   to Alfa Estimator
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                        Pitch Gimbal Deflects DY (1-8)
System Input  2 to Subsystem  1, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  1, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  1, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  1, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  1, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  1, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  1, Input  8, Gain= 1.00000            
System Input 21 to Subsystem  1, Input  9, Gain= 1.00000                                        Pitch Rate Q
System Input 23 to Subsystem  1, Input 10, Gain= 1.00000                                        NZ Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   to Beta Estimator
System Input  9 to Subsystem  2, Input  1, Gain= 1.00000                                        Yaw Gimbal Deflects DZ (1-8)
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  2, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  2, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  2, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  2, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  2, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  2, Input  8, Gain= 1.00000            
System Input 22 to Subsystem  2, Input  9, Gain= 1.00000                                        Yaw Rate R
System Input 24 to Subsystem  2, Input 10, Gain= 1.00000                                        NY Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   to Low-Pass Filters 
System Input 17 to Subsystem  3, Input  1, Gain= 2.5                                            KL_phi
System Input 18 to Subsystem  3, Input  2, Gain= 2.76                                           KM_theta
System Input 19 to Subsystem  3, Input  3, Gain= 2.76                                           KN_psi
System Input 20 to Subsystem  3, Input  1, Gain= 2.2                                            KL_p
System Input 21 to Subsystem  3, Input  2, Gain= 2.3                                            KM_q
System Input 22 to Subsystem  3, Input  3, Gain= 2.3                                            KN_r
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                                   to Integrator-4
System Input 18 to Subsystem  4, Input  1, Gain= 1.0                                            Theta
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                                   to Integrator-5
System Input 19 to Subsystem  5, Input  1, Gain= 1.0                                            Psi
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Alfa Estim to Filters
Subsystem  1, Output  1 to Subsystem  3, Input  2, Gain= 0.02                                   KM_alfa
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                                         Beta Estim to Filters
Subsystem  2, Output  1 to Subsystem  3, Input  3, Gain= -0.02                                  KN_beta= - Km_alfa
..............................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  3                                                         Theta-int to Low-Pass
Subsystem  4, Output  1 to Subsystem  3, Input  2, Gain= 0.43                                   KM_thint
..............................................................................
SUBSYSTEM NO  5 GOES TO SUBSYSTEM NO  3                                                         Psi-int to to Low-Pass
Subsystem  5, Output  1 to Subsystem  3, Input  3, Gain= 0.43                                   KN_psint
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                from Low-Pass Filters 
System Output  1 from Subsystem  3, Output  1, Gain= -1.0                                       DP_tvc
System Output  2 from Subsystem  3, Output  2, Gain= -1.0                                       DQ_tvc
System Output  3 from Subsystem  3, Output  3, Gain= -1.0                                       DR_tvc
..............................................................................
Definitions of Inputs  =  24
Engine Pitch Deflect Comd delta y_1 (rad)  
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)  
Roll  Attitude Error (rad)                  
Pitch Attitude Error (rad)
Yaw   Attitude Error (rad)
Roll  Rate (rad/sec)                        
Pitch Rate (rad/sec)
Yaw   Rate (rad/sec)
Normal  Acceleration NZ (ft/sec^2)         
Lateral Acceleration NY (ft/sec^2)         
 
Definitions of Outputs =   3
Roll  FCS Demand DP_tvc
Pitch FCS Demand DQ_tvc
Yaw   FCS Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Closed-Loop System
! Combines the Plant Model with the Flight Control System in
! Closed-Loop form
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=10 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
System Input  1 to Subsystem  1, Input 17, Gain= -1.0                                                      Roll Command
System Input  2 to Subsystem  1, Input 18, Gain= -1.0                                                      Ptch Command
System Input  3 to Subsystem  1, Input 19, Gain= -1.0                                                      Yaw  Command
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehi
System Input  4 to Subsystem  2, Input 17, Gain=  1.0                                                      Wind Gust
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    FCS
Via Matrix +TVC                                                                     
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                                    FCS to Vehi
Via Matrix +TVC                                                                                            DY(8), DZ(8)                                                                     
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                           Vehicle Outputs
Via Matrix +I32                                                                     
..............................................................................
Definitions of Inputs  =   4
Roll  Attitude Command (rad)  
Pitch Attitude Command (rad)  
Yaw   Attitude Command (rad)  
Wind-Gust Velocity (feet/sec)

Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Open-Loop System
! Combines the Plant Model with the Flight Control System in
! Open-Loop config
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=10 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehicle
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           Vehicle Outputs
Via Matrix +I03                                                                     
..............................................................................
Definitions of Inputs  =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc

Definitions of Outputs =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Roll Loop Opened, Others Closed
! Roll Loop Opened for Roll Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                                       Roll Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  1, Gain= -1.0                                                  DP_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw Closed
..............................................................................
Definitions of Inputs  =   1
Roll Control Demand DP_tvc 

Definitions of Outputs =   1
Roll Control Demand DP_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Pitch Loop Opened, Others Closed
! Pitch Loop Opened for Pitch Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  2, Gain= 1.0                                                       Pitch Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  2, Gain= -1.0                                                  DQ_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw  Closed
..............................................................................
Definitions of Inputs  =   1
Pitch Control Demand DQ_tvc 

Definitions of Outputs =   1
Pitch Control Demand DQ_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Yaw Loop Opened, Others Closed
! Roll Loop Opened for Yaw Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  3, Gain= 1.0                                                       Yaw Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  3, Gain= -1.0                                                  DR_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll  Closed
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
..............................................................................
Definitions of Inputs  =   1
Yaw Control Demand DR_tvc 

Definitions of Outputs =   1
Yaw Control Demand DR_tvc 
--------------------------------------------------------------------------------------------------------------------------------
                            CONVERT TO MATLAB DATA
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=10.0 sec 
Matrix TVC
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=10.0 sec 
System
flex_vehicle.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Flight Control System
System
fcs.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model at T=10 sec, Vehicle/ Actuators
System
plant.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Closed-Loop System
System
closed_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Open-Loop System
System
open_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Roll Loop Opened, Others Closed
System
roll_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Loop Opened, Others Closed
System
pitch_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Yaw Loop Opened, Others Closed
System
yaw_open.m
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 100% Full 
First Stage Flex Modes at 100% Full Tanks
! Flex Modes, First Stage 100% Full Tanks from Files: Stg1_100%.Mod, Stg1_100%.Nod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    19.194       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11835D-01  -0.11684D+00   0.66210D-02   0.16324D-05   0.27168D-03   0.48347D-02
S1 Engine No:2 +Y-Z               1152    -0.54460D-02  -0.11683D+00   0.66203D-02  -0.26923D-06   0.27091D-03   0.48442D-02
S1 Engine No:3 -Y-Z               1153     0.41356D-02  -0.11683D+00   0.66217D-02  -0.68227D-07   0.27704D-03   0.48445D-02
S1 Engine No:4 -Y-Z               1154     0.11292D-01  -0.11684D+00   0.66208D-02   0.15055D-05   0.27746D-03   0.48349D-02
S1 Engine No:5 -Y+Z               1155     0.11835D-01  -0.11684D+00   0.66208D-02  -0.16901D-05   0.27175D-03   0.48347D-02
S1 Engine No:6 -Y+Z               1156     0.54463D-02  -0.11683D+00   0.66202D-02   0.47088D-06   0.27080D-03   0.48442D-02
S1 Engine No:7 +Y+Z               1157    -0.41355D-02  -0.11683D+00   0.66220D-02   0.16997D-06   0.27713D-03   0.48445D-02
S1 Engine No:8 +Y+Z               1158    -0.11292D-01  -0.11684D+00   0.66211D-02  -0.17161D-05   0.27732D-03   0.48350D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02   0.48748D-08  -0.23545D-03  -0.41551D-02
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02   0.48748D-08  -0.23545D-03  -0.41551D-02
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02   0.48748D-08  -0.23545D-03  -0.41551D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.57960D-07   0.31849D-01  -0.18050D-02   0.48010D-08  -0.12250D-03  -0.21616D-02
Fuel Slosh Mass Locat.             600     0.88999D-07   0.13928D-01  -0.78942D-03   0.43838D-08   0.18448D-03   0.32552D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.22434D-04  -0.11741D+00   0.66533D-02  -0.16100D-04   0.29930D-03   0.52819D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    19.194       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.41359D-02  -0.66222D-02  -0.11685D+00  -0.20140D-07  -0.48449D-02   0.27714D-03
S1 Engine No:2 +Y-Z               1152     0.11293D-01  -0.66214D-02  -0.11685D+00   0.15100D-05  -0.48355D-02   0.27748D-03
S1 Engine No:3 -Y-Z               1153     0.11836D-01  -0.66213D-02  -0.11685D+00  -0.14620D-05  -0.48352D-02   0.27162D-03
S1 Engine No:4 -Y-Z               1154     0.54466D-02  -0.66208D-02  -0.11685D+00   0.35777D-06  -0.48445D-02   0.27084D-03
S1 Engine No:5 -Y+Z               1155    -0.41359D-02  -0.66225D-02  -0.11685D+00   0.22565D-06  -0.48449D-02   0.27718D-03
S1 Engine No:6 -Y+Z               1156    -0.11293D-01  -0.66217D-02  -0.11685D+00  -0.15606D-05  -0.48354D-02   0.27738D-03
S1 Engine No:7 +Y+Z               1157    -0.11836D-01  -0.66217D-02  -0.11685D+00   0.16506D-05  -0.48350D-02   0.27166D-03
S1 Engine No:8 +Y+Z               1158    -0.54465D-02  -0.66209D-02  -0.11685D+00  -0.23070D-06  -0.48445D-02   0.27085D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01   0.69856D-07   0.41550D-02  -0.23548D-03
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01   0.69856D-07   0.41550D-02  -0.23548D-03
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01   0.69856D-07   0.41550D-02  -0.23548D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.15673D-08   0.18050D-02   0.31854D-01   0.68749D-07   0.21616D-02  -0.12250D-03
Fuel Slosh Mass Locat.             600     0.34213D-08   0.78913D-03   0.13928D-01   0.64733D-07  -0.32556D-02   0.18449D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.13079D-05  -0.66539D-02  -0.11742D+00   0.87809D-05  -0.52823D-02   0.29942D-03

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.528       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.48160D-02  -0.28314D-01   0.12098D-05   0.21767D-05  -0.27155D-05   0.19589D-02
S1 Engine No:2 +Y-Z               1152    -0.20629D-02  -0.28312D-01   0.69448D-07  -0.24954D-06  -0.29168D-05   0.19700D-02
S1 Engine No:3 -Y-Z               1153     0.18360D-02  -0.28312D-01   0.19790D-05  -0.20318D-06   0.33606D-05   0.19699D-02
S1 Engine No:4 -Y-Z               1154     0.45895D-02  -0.28314D-01   0.85872D-06   0.20230D-05   0.32454D-05   0.19586D-02
S1 Engine No:5 -Y+Z               1155     0.45901D-02  -0.28314D-01   0.87727D-06  -0.22668D-05  -0.27131D-05   0.19588D-02
S1 Engine No:6 -Y+Z               1156     0.18367D-02  -0.28312D-01   0.38930D-07   0.52456D-06  -0.32766D-05   0.19700D-02
S1 Engine No:7 +Y+Z               1157    -0.20623D-02  -0.28312D-01   0.23114D-05   0.34675D-06   0.32909D-05   0.19700D-02
S1 Engine No:8 +Y+Z               1158    -0.48158D-02  -0.28314D-01   0.12144D-05  -0.23402D-05   0.29380D-05   0.19589D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06   0.11416D-07   0.15265D-06   0.22859D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06   0.11416D-07   0.15265D-06   0.22859D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06   0.11416D-07   0.15265D-06   0.22859D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.73425D-04  -0.15759D-01   0.16115D-05   0.99748D-08  -0.14588D-07  -0.50269D-03
Fuel Slosh Mass Locat.             600    -0.10492D-03   0.16280D-01  -0.15120D-05   0.59382D-08  -0.43114D-07   0.18158D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.76380D-04  -0.29231D-01   0.25172D-05  -0.25876D-04   0.10672D-05   0.26642D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    49.519       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.58148D-02  -0.16675D-04   0.80590D-01   0.67472D-06   0.58712D-02  -0.88050D-05
S1 Engine No:2 +Y-Z               1152    -0.14019D-01  -0.19943D-04   0.80597D-01  -0.66138D-05   0.58349D-02  -0.81954D-05
S1 Engine No:3 -Y-Z               1153    -0.14016D-01  -0.19683D-04   0.80596D-01   0.67158D-05   0.58350D-02   0.11492D-04
S1 Engine No:4 -Y-Z               1154    -0.58067D-02  -0.22653D-04   0.80590D-01  -0.10378D-05   0.58714D-02   0.12341D-04
S1 Engine No:5 -Y+Z               1155     0.58152D-02  -0.15771D-04   0.80590D-01  -0.12808D-05   0.58716D-02  -0.89446D-05
S1 Engine No:6 -Y+Z               1156     0.14019D-01  -0.19041D-04   0.80597D-01   0.73584D-05   0.58348D-02  -0.76537D-05
S1 Engine No:7 +Y+Z               1157     0.14015D-01  -0.18951D-04   0.80597D-01  -0.71932D-05   0.58348D-02   0.11324D-04
S1 Engine No:8 +Y+Z               1158     0.58067D-02  -0.22591D-04   0.80590D-01   0.77198D-06   0.58714D-02   0.12310D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01  -0.59874D-07   0.55176D-02   0.14255D-05
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01  -0.59874D-07   0.55176D-02   0.14255D-05
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01  -0.59874D-07   0.55176D-02   0.14255D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.11194D-07  -0.16238D-04   0.52694D-01  -0.76328D-07  -0.99685D-03  -0.17519D-06
Fuel Slosh Mass Locat.             600     0.16082D-07   0.14572D-04  -0.47540D-01  -0.89460D-07   0.17190D-04  -0.21182D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.88496D-07  -0.26002D-04   0.83710D-01  -0.55020D-04   0.82306D-02   0.58724D-05

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    50.988       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.15330D-01   0.86878D-01   0.25245D-04  -0.83622D-05   0.12166D-04  -0.63998D-02
S1 Engine No:2 +Y-Z               1152     0.63254D-02   0.86870D-01   0.29642D-04   0.96854D-06   0.13128D-04  -0.64420D-02
S1 Engine No:3 -Y-Z               1153    -0.64260D-02   0.86870D-01   0.22333D-04   0.78264D-06  -0.97150D-05  -0.64418D-02
S1 Engine No:4 -Y-Z               1154    -0.15427D-01   0.86878D-01   0.26635D-04  -0.77536D-05  -0.95665D-05  -0.63998D-02
S1 Engine No:5 -Y+Z               1155    -0.15425D-01   0.86876D-01   0.26486D-04   0.87222D-05   0.11758D-04  -0.64004D-02
S1 Engine No:6 -Y+Z               1156    -0.64188D-02   0.86869D-01   0.29714D-04  -0.20171D-05   0.13628D-04  -0.64423D-02
S1 Engine No:7 +Y+Z               1157     0.63332D-02   0.86869D-01   0.21018D-04  -0.13366D-05  -0.10345D-04  -0.64420D-02
S1 Engine No:8 +Y+Z               1158     0.15334D-01   0.86877D-01   0.25266D-04   0.90170D-05  -0.87638D-05  -0.63998D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05  -0.49861D-07   0.15511D-05  -0.53716D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05  -0.49861D-07   0.15511D-05  -0.53716D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05  -0.49861D-07   0.15511D-05  -0.53716D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.24363D-04   0.58718D-01   0.13419D-04  -0.42239D-07  -0.34873D-06   0.83621D-03
Fuel Slosh Mass Locat.             600    -0.41249D-04  -0.51680D-01  -0.11729D-04  -0.21478D-07   0.21264D-06   0.18689D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.19907D-03   0.90567D-01   0.19297D-04   0.10513D-03  -0.25526D-05  -0.92272D-02

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    53.995       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.32957D-02   0.13441D-04   0.43432D-01   0.55919D-06   0.33313D-02  -0.70805D-05
S1 Engine No:2 +Y-Z               1152    -0.79525D-02   0.11527D-04   0.43436D-01  -0.40969D-05   0.33085D-02  -0.67261D-05
S1 Engine No:3 -Y-Z               1153    -0.79539D-02   0.11722D-04   0.43436D-01   0.44260D-05   0.33085D-02   0.53218D-05
S1 Engine No:4 -Y-Z               1154    -0.32989D-02   0.96389D-05   0.43432D-01  -0.53737D-06   0.33313D-02   0.58553D-05
S1 Engine No:5 -Y+Z               1155     0.32959D-02   0.13768D-04   0.43432D-01  -0.68957D-06   0.33314D-02  -0.71707D-05
S1 Engine No:6 -Y+Z               1156     0.79525D-02   0.11486D-04   0.43436D-01   0.48414D-05   0.33084D-02  -0.63750D-05
S1 Engine No:7 +Y+Z               1157     0.79536D-02   0.11571D-04   0.43436D-01  -0.44732D-05   0.33084D-02   0.52132D-05
S1 Engine No:8 +Y+Z               1158     0.32989D-02   0.94194D-05   0.43432D-01   0.62680D-06   0.33313D-02   0.58350D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02  -0.22952D-07   0.19405D-02  -0.58346D-06
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02  -0.22952D-07   0.19405D-02  -0.58346D-06
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02  -0.22952D-07   0.19405D-02  -0.58346D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10917D-08   0.59514D-05   0.30128D-01   0.93208D-08  -0.12114D-03   0.12337D-06
Fuel Slosh Mass Locat.             600    -0.28225D-08  -0.49153D-05  -0.26139D-01   0.58660D-07  -0.29987D-03  -0.94716D-07

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.44869D-07   0.72636D-05   0.45500D-01  -0.36629D-04   0.48913D-02   0.20015D-05

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.683       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.77430D-02   0.32333D-01  -0.15578D-03  -0.69110D-05  -0.10335D-04  -0.31972D-02
S1 Engine No:2 +Y-Z               1152     0.32590D-02   0.32326D-01  -0.15218D-03   0.93539D-06  -0.96658D-05  -0.32274D-02
S1 Engine No:3 -Y-Z               1153    -0.31316D-02   0.32326D-01  -0.15827D-03   0.70309D-06  -0.22667D-04  -0.32273D-02
S1 Engine No:4 -Y-Z               1154    -0.76613D-02   0.32332D-01  -0.15469D-03  -0.63479D-05  -0.22914D-04  -0.31969D-02
S1 Engine No:5 -Y+Z               1155    -0.76948D-02   0.32331D-01  -0.15509D-03   0.74357D-05  -0.10613D-04  -0.31975D-02
S1 Engine No:6 -Y+Z               1156    -0.32099D-02   0.32324D-01  -0.15229D-03  -0.17125D-05  -0.89902D-05  -0.32278D-02
S1 Engine No:7 +Y+Z               1157     0.31813D-02   0.32324D-01  -0.15929D-03  -0.10157D-05  -0.23010D-04  -0.32275D-02
S1 Engine No:8 +Y+Z               1158     0.77111D-02   0.32332D-01  -0.15549D-03   0.76890D-05  -0.22082D-04  -0.31973D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03  -0.11856D-06   0.33664D-04   0.67061D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03  -0.11856D-06   0.33664D-04   0.67061D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03  -0.11856D-06   0.33664D-04   0.67061D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.74179D-05  -0.58567D-02   0.32349D-04  -0.77764D-07  -0.15433D-04  -0.30749D-02
Fuel Slosh Mass Locat.             600     0.22403D-04  -0.19267D-01   0.95590D-04   0.92743D-08   0.65914D-05   0.12486D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.16033D-03   0.36557D-01  -0.20016D-03   0.12786D-03  -0.48155D-04  -0.63548D-02

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.766       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.31253D-02   0.17076D-03   0.32081D-01   0.80204D-06   0.31951D-02  -0.22608D-04
S1 Engine No:2 +Y-Z               1152    -0.76103D-02   0.16787D-03   0.32087D-01  -0.60214D-05   0.31656D-02  -0.22450D-04
S1 Engine No:3 -Y-Z               1153    -0.76420D-02   0.16841D-03   0.32086D-01   0.65590D-05   0.31656D-02  -0.95069D-05
S1 Engine No:4 -Y-Z               1154    -0.32013D-02   0.16532D-03   0.32080D-01  -0.83570D-06   0.31951D-02  -0.87563D-05
S1 Engine No:5 -Y+Z               1155     0.31259D-02   0.17128D-03   0.32080D-01  -0.10049D-05   0.31955D-02  -0.22751D-04
S1 Engine No:6 -Y+Z               1156     0.76107D-02   0.16780D-03   0.32087D-01   0.72080D-05   0.31655D-02  -0.21888D-04
S1 Engine No:7 +Y+Z               1157     0.76418D-02   0.16816D-03   0.32088D-01  -0.66332D-05   0.31654D-02  -0.96786D-05
S1 Engine No:8 +Y+Z               1158     0.32015D-02   0.16496D-03   0.32081D-01   0.97784D-06   0.31951D-02  -0.87920D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01  -0.95857D-07  -0.66751D-02   0.33552D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01  -0.95857D-07  -0.66751D-02   0.33552D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01  -0.95857D-07  -0.66751D-02   0.33552D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.22458D-07  -0.26901D-04  -0.59334D-02  -0.11330D-07   0.30594D-02  -0.15379D-04
Fuel Slosh Mass Locat.             600     0.11036D-06  -0.97010D-04  -0.19081D-01   0.97547D-07  -0.12340D-02   0.58794D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.75747D-07   0.16447D-03   0.35977D-01  -0.72496D-04   0.60902D-02  -0.14819D-04

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    98.803       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.28567D-01   0.89020D-01  -0.72209D-02  -0.25456D-04  -0.93281D-03  -0.11512D-01
S1 Engine No:2 +Y-Z               1152     0.13670D-01   0.88996D-01  -0.72151D-02   0.12635D-04  -0.92252D-03  -0.11623D-01
S1 Engine No:3 -Y-Z               1153    -0.93417D-02   0.88996D-01  -0.72538D-02   0.71268D-05  -0.94780D-03  -0.11625D-01
S1 Engine No:4 -Y-Z               1154    -0.26875D-01   0.89021D-01  -0.72436D-02  -0.22033D-04  -0.95899D-03  -0.11514D-01
S1 Engine No:5 -Y+Z               1155    -0.28751D-01   0.88997D-01  -0.72469D-02   0.40658D-04  -0.93496D-03  -0.11515D-01
S1 Engine No:6 -Y+Z               1156    -0.13850D-01   0.88959D-01  -0.72279D-02  -0.44970D-05  -0.92051D-03  -0.11626D-01
S1 Engine No:7 +Y+Z               1157     0.91652D-02   0.88959D-01  -0.72471D-02   0.38098D-05  -0.95077D-03  -0.11625D-01
S1 Engine No:8 +Y+Z               1158     0.26699D-01   0.89004D-01  -0.72182D-02   0.41219D-04  -0.95544D-03  -0.11515D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03  -0.75408D-05   0.55742D-04   0.68892D-03
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03  -0.75408D-05   0.55742D-04   0.68892D-03
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03  -0.75408D-05   0.55742D-04   0.68892D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.55070D-04  -0.92059D-02   0.74749D-03  -0.31501D-05  -0.88537D-04  -0.10899D-02
Fuel Slosh Mass Locat.             600    -0.24521D-04  -0.41341D-01   0.33607D-02   0.30340D-05   0.34400D-03   0.42319D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.15721D-02   0.12047D+00  -0.97938D-02   0.10663D-02  -0.27991D-02  -0.34440D-01

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    99.014       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.93336D-02   0.73877D-02   0.90708D-01  -0.55645D-06   0.11719D-01  -0.95914D-03
S1 Engine No:2 +Y-Z               1152    -0.27014D-01   0.73689D-02   0.90742D-01  -0.29412D-04   0.11608D-01  -0.96830D-03
S1 Engine No:3 -Y-Z               1153    -0.28902D-01   0.73729D-02   0.90740D-01   0.28934D-04   0.11606D-01  -0.93811D-03
S1 Engine No:4 -Y-Z               1154    -0.13879D-01   0.73635D-02   0.90713D-01  -0.81139D-05   0.11718D-01  -0.92722D-03
S1 Engine No:5 -Y+Z               1155     0.93224D-02   0.73935D-02   0.90712D-01  -0.40928D-05   0.11721D-01  -0.96006D-03
S1 Engine No:6 -Y+Z               1156     0.27002D-01   0.73771D-02   0.90744D-01   0.31358D-04   0.11608D-01  -0.96557D-03
S1 Engine No:7 +Y+Z               1157     0.28887D-01   0.73803D-02   0.90742D-01  -0.33253D-04   0.11605D-01  -0.93900D-03
S1 Engine No:8 +Y+Z               1158     0.13866D-01   0.73651D-02   0.90708D-01   0.54815D-05   0.11718D-01  -0.92743D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02   0.13378D-05  -0.69455D-03   0.56732D-04
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02   0.13378D-05  -0.69455D-03   0.56732D-04
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02   0.13378D-05  -0.69455D-03   0.56732D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.38678D-05  -0.73731D-03  -0.90582D-02   0.56479D-06   0.11043D-02  -0.89848D-04
Fuel Slosh Mass Locat.             600    -0.16951D-05  -0.34148D-02  -0.42003D-01  -0.53178D-06  -0.42436D-02   0.34501D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.10928D-03   0.95353D-02   0.11727D+00  -0.46031D-03   0.31105D-01  -0.25321D-02

MODE# 11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    102.26       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.92163D-05   0.22601D-01   0.54644D-01   0.22891D-01   0.84820D-06   0.38878D-05
S1 Engine No:2 +Y-Z               1152    -0.55848D-05   0.54606D-01   0.22639D-01   0.22891D-01   0.33014D-06   0.33446D-05
S1 Engine No:3 -Y-Z               1153     0.80772D-06   0.54606D-01  -0.22623D-01   0.22891D-01   0.14764D-05   0.33539D-05
S1 Engine No:4 -Y-Z               1154     0.69195D-05   0.22601D-01  -0.54628D-01   0.22891D-01   0.92426D-06   0.38308D-05
S1 Engine No:5 -Y+Z               1155     0.84918D-05  -0.22661D-01  -0.54628D-01   0.22891D-01   0.90648D-06   0.27097D-05
S1 Engine No:6 -Y+Z               1156     0.52666D-05  -0.54666D-01  -0.22623D-01   0.22891D-01   0.13944D-05   0.33220D-05
S1 Engine No:7 +Y+Z               1157    -0.15504D-05  -0.54666D-01   0.22639D-01   0.22891D-01   0.30354D-06   0.33161D-05
S1 Engine No:8 +Y+Z               1158    -0.72555D-05  -0.22661D-01   0.54644D-01   0.22891D-01   0.88757D-06   0.27700D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05  -0.28561D-01  -0.34303D-06  -0.20275D-06
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05  -0.28561D-01  -0.34303D-06  -0.20275D-06
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05  -0.28561D-01  -0.34303D-06  -0.20275D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.12519D-06   0.16611D-05  -0.12105D-05  -0.10382D-01   0.14159D-06   0.34177D-06
Fuel Slosh Mass Locat.             600    -0.84227D-07   0.13478D-04  -0.36743D-05   0.12420D-01  -0.31908D-06  -0.11187D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.28565D-05  -0.92126D-05  -0.31152D-05   0.26162D-01  -0.10583D-04  -0.14358D-04

MODE# 12/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    109.98       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.36829D-05   0.15646D-01   0.37808D-01   0.15839D-01   0.32694D-06   0.15230D-05
S1 Engine No:2 +Y-Z               1152    -0.25167D-05   0.37791D-01   0.15663D-01   0.15839D-01  -0.85690D-07   0.10763D-05
S1 Engine No:3 -Y-Z               1153    -0.56940D-06   0.37791D-01  -0.15655D-01   0.15839D-01   0.83436D-06   0.10817D-05
S1 Engine No:4 -Y-Z               1154     0.15970D-05   0.15646D-01  -0.37800D-01   0.15839D-01   0.38783D-06   0.14722D-05
S1 Engine No:5 -Y+Z               1155     0.21558D-05  -0.15672D-01  -0.37800D-01   0.15839D-01   0.37084D-06   0.57247D-06
S1 Engine No:6 -Y+Z               1156     0.13173D-05  -0.37817D-01  -0.15655D-01   0.15839D-01   0.76304D-06   0.10561D-05
S1 Engine No:7 +Y+Z               1157    -0.97148D-06  -0.37817D-01   0.15663D-01   0.15839D-01  -0.11196D-06   0.10540D-05
S1 Engine No:8 +Y+Z               1158    -0.28103D-05  -0.15672D-01   0.37808D-01   0.15839D-01   0.35693D-06   0.62642D-06

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05  -0.19726D-01   0.79814D-06  -0.37598D-07
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05  -0.19726D-01   0.79814D-06  -0.37598D-07
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05  -0.19726D-01   0.79814D-06  -0.37598D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.30837D-06  -0.33980D-06   0.28099D-05  -0.79243D-02  -0.13068D-06   0.13364D-06
Fuel Slosh Mass Locat.             600    -0.30723D-06   0.59627D-05  -0.21820D-05   0.75040D-02  -0.62951D-07  -0.30580D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.36268D-05   0.19274D-04  -0.98857D-05   0.18522D-01  -0.12389D-04  -0.24172D-04

MODE# 13/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    124.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.21235D-02  -0.66494D-02  -0.80960D-05   0.37308D-05   0.11405D-04   0.96781D-03
S1 Engine No:2 +Y-Z               1152    -0.77494D-03  -0.66454D-02  -0.10086D-04  -0.61187D-06   0.10725D-04   0.98023D-03
S1 Engine No:3 -Y-Z               1153     0.11666D-02  -0.66455D-02  -0.67337D-05  -0.49172D-06   0.11407D-04   0.98124D-03
S1 Engine No:4 -Y-Z               1154     0.25497D-02  -0.66493D-02  -0.86242D-05   0.33469D-05   0.12412D-04   0.97049D-03
S1 Engine No:5 -Y+Z               1155     0.25749D-02  -0.66480D-02  -0.80903D-05  -0.42072D-05   0.12978D-04   0.97116D-03
S1 Engine No:6 -Y+Z               1156     0.12258D-02  -0.66441D-02  -0.97536D-05   0.92756D-06   0.13446D-04   0.98180D-03
S1 Engine No:7 +Y+Z               1157    -0.71618D-03  -0.66441D-02  -0.61132D-05   0.56344D-06   0.14760D-04   0.97998D-03
S1 Engine No:8 +Y+Z               1158    -0.20993D-02  -0.66485D-02  -0.84301D-05  -0.44021D-05   0.13262D-04   0.96755D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03  -0.25290D-05  -0.24515D-03  -0.14803D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03  -0.25290D-05  -0.24515D-03  -0.14803D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03  -0.25290D-05  -0.24515D-03  -0.14803D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.13168D-03   0.61922D-01  -0.10506D-02  -0.34141D-06   0.50370D-04   0.31469D-02
Fuel Slosh Mass Locat.             600     0.73772D-04  -0.67523D-02   0.18941D-03   0.74642D-06  -0.22272D-04  -0.13788D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.12818D-02  -0.26849D-01   0.10777D-02  -0.73744D-03   0.77426D-03   0.15258D-01

MODE# 14/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    124.98       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.10054D-02   0.27377D-03   0.85836D-02   0.71408D-06   0.10586D-02  -0.24233D-04
S1 Engine No:2 +Y-Z               1152    -0.25115D-02   0.27183D-03   0.85879D-02  -0.40939D-05   0.10407D-02  -0.25002D-04
