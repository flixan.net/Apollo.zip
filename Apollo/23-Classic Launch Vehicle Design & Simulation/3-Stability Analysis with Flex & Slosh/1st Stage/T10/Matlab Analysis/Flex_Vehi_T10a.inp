BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=10 sec
! This batch set creates dynamic models for Control Analysis at T=10 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=10.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=10.0 sec 
Actuator Model   : Stage-1 Linear Actuator
!
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=10.0 sec            
To Matlab Format : Mixing Logic for First Stage Model, at T=10.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=10.0 sec                                       
! This is a Launch Vehicle Control Analysis Model at t=10 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 100% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.012 .
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   5070.0        32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   36805.3      0.281044E+07  0.280948E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   57.8656       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.071         79.6400       7.38000       384.843    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   8.8           40.88         0.0          -0.001
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.54          0.0          -0.09          0.000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           89.67         0.00000       0.0           0.001        -0.0
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.00         90.00                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.415        7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.4405       -0.00081       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  -0.0          -0.03557       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.0061       -0.03557       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.27          0.1114        0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          -0.1114        0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945       -1.0332     
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332       -2.4945 
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332       -2.4945
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945       -1.0332 
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945        1.0332
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332        2.4945
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332        2.4945
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   22803.1       22803.1
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945        1.0332 

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438    0.000      0.000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438    0.000      0.000    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438    0.000      0.000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000       

Number of Slosh Modes                                                                    :  2
LOX Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   121.51   3.11   3.11   0.005  0.005  71.09   0.0  0.0   
LH2 Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   41.906   3.11   3.11   0.001  0.001  41.16   0.0  0.0 

Number of Bending Modes                                                                  : 31
First Stage Flex Modes at 100% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=10.0 sec 
! Thrust Vector Control Matrix at t=10 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=10.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=10.0 sec 
Matrix TVC
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=10.0 sec 
System
flex_vehicle.m
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
--------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 100% Full 
First Stage Flex Modes at 100% Full Tanks
! Flex Modes, First Stage 100% Full Tanks from Files: Stg1_100%.Mod, Stg1_100%.Nod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    19.194       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11835D-01  -0.11684D+00   0.66210D-02   0.16324D-05   0.27168D-03   0.48347D-02
S1 Engine No:2 +Y-Z               1152    -0.54460D-02  -0.11683D+00   0.66203D-02  -0.26923D-06   0.27091D-03   0.48442D-02
S1 Engine No:3 -Y-Z               1153     0.41356D-02  -0.11683D+00   0.66217D-02  -0.68227D-07   0.27704D-03   0.48445D-02
S1 Engine No:4 -Y-Z               1154     0.11292D-01  -0.11684D+00   0.66208D-02   0.15055D-05   0.27746D-03   0.48349D-02
S1 Engine No:5 -Y+Z               1155     0.11835D-01  -0.11684D+00   0.66208D-02  -0.16901D-05   0.27175D-03   0.48347D-02
S1 Engine No:6 -Y+Z               1156     0.54463D-02  -0.11683D+00   0.66202D-02   0.47088D-06   0.27080D-03   0.48442D-02
S1 Engine No:7 +Y+Z               1157    -0.41355D-02  -0.11683D+00   0.66220D-02   0.16997D-06   0.27713D-03   0.48445D-02
S1 Engine No:8 +Y+Z               1158    -0.11292D-01  -0.11684D+00   0.66211D-02  -0.17161D-05   0.27732D-03   0.48350D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02   0.48748D-08  -0.23545D-03  -0.41551D-02
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02   0.48748D-08  -0.23545D-03  -0.41551D-02
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02   0.48748D-08  -0.23545D-03  -0.41551D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02
Stage-2 Tank Top, IMU Locat.     40015     0.41474D-07  -0.54406D-01   0.30829D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.57960D-07   0.31849D-01  -0.18050D-02   0.48010D-08  -0.12250D-03  -0.21616D-02
Fuel Slosh Mass Locat.             600     0.88999D-07   0.13928D-01  -0.78942D-03   0.43838D-08   0.18448D-03   0.32552D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.22434D-04  -0.11741D+00   0.66533D-02  -0.16100D-04   0.29930D-03   0.52819D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    19.194       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.41359D-02  -0.66222D-02  -0.11685D+00  -0.20140D-07  -0.48449D-02   0.27714D-03
S1 Engine No:2 +Y-Z               1152     0.11293D-01  -0.66214D-02  -0.11685D+00   0.15100D-05  -0.48355D-02   0.27748D-03
S1 Engine No:3 -Y-Z               1153     0.11836D-01  -0.66213D-02  -0.11685D+00  -0.14620D-05  -0.48352D-02   0.27162D-03
S1 Engine No:4 -Y-Z               1154     0.54466D-02  -0.66208D-02  -0.11685D+00   0.35777D-06  -0.48445D-02   0.27084D-03
S1 Engine No:5 -Y+Z               1155    -0.41359D-02  -0.66225D-02  -0.11685D+00   0.22565D-06  -0.48449D-02   0.27718D-03
S1 Engine No:6 -Y+Z               1156    -0.11293D-01  -0.66217D-02  -0.11685D+00  -0.15606D-05  -0.48354D-02   0.27738D-03
S1 Engine No:7 +Y+Z               1157    -0.11836D-01  -0.66217D-02  -0.11685D+00   0.16506D-05  -0.48350D-02   0.27166D-03
S1 Engine No:8 +Y+Z               1158    -0.54465D-02  -0.66209D-02  -0.11685D+00  -0.23070D-06  -0.48445D-02   0.27085D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01   0.69856D-07   0.41550D-02  -0.23548D-03
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01   0.69856D-07   0.41550D-02  -0.23548D-03
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01   0.69856D-07   0.41550D-02  -0.23548D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01
Stage-2 Tank Top, IMU Locat.     40015     0.60192D-09  -0.30832D-02  -0.54402D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.15673D-08   0.18050D-02   0.31854D-01   0.68749D-07   0.21616D-02  -0.12250D-03
Fuel Slosh Mass Locat.             600     0.34213D-08   0.78913D-03   0.13928D-01   0.64733D-07  -0.32556D-02   0.18449D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.13079D-05  -0.66539D-02  -0.11742D+00   0.87809D-05  -0.52823D-02   0.29942D-03

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.528       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.48160D-02  -0.28314D-01   0.12098D-05   0.21767D-05  -0.27155D-05   0.19589D-02
S1 Engine No:2 +Y-Z               1152    -0.20629D-02  -0.28312D-01   0.69448D-07  -0.24954D-06  -0.29168D-05   0.19700D-02
S1 Engine No:3 -Y-Z               1153     0.18360D-02  -0.28312D-01   0.19790D-05  -0.20318D-06   0.33606D-05   0.19699D-02
S1 Engine No:4 -Y-Z               1154     0.45895D-02  -0.28314D-01   0.85872D-06   0.20230D-05   0.32454D-05   0.19586D-02
S1 Engine No:5 -Y+Z               1155     0.45901D-02  -0.28314D-01   0.87727D-06  -0.22668D-05  -0.27131D-05   0.19588D-02
S1 Engine No:6 -Y+Z               1156     0.18367D-02  -0.28312D-01   0.38930D-07   0.52456D-06  -0.32766D-05   0.19700D-02
S1 Engine No:7 +Y+Z               1157    -0.20623D-02  -0.28312D-01   0.23114D-05   0.34675D-06   0.32909D-05   0.19700D-02
S1 Engine No:8 +Y+Z               1158    -0.48158D-02  -0.28314D-01   0.12144D-05  -0.23402D-05   0.29380D-05   0.19589D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06   0.11416D-07   0.15265D-06   0.22859D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06   0.11416D-07   0.15265D-06   0.22859D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06   0.11416D-07   0.15265D-06   0.22859D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.51358D-04   0.68201D-02  -0.42776D-06

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.73425D-04  -0.15759D-01   0.16115D-05   0.99748D-08  -0.14588D-07  -0.50269D-03
Fuel Slosh Mass Locat.             600    -0.10492D-03   0.16280D-01  -0.15120D-05   0.59382D-08  -0.43114D-07   0.18158D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.76380D-04  -0.29231D-01   0.25172D-05  -0.25876D-04   0.10672D-05   0.26642D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    49.519       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.58148D-02  -0.16675D-04   0.80590D-01   0.67472D-06   0.58712D-02  -0.88050D-05
S1 Engine No:2 +Y-Z               1152    -0.14019D-01  -0.19943D-04   0.80597D-01  -0.66138D-05   0.58349D-02  -0.81954D-05
S1 Engine No:3 -Y-Z               1153    -0.14016D-01  -0.19683D-04   0.80596D-01   0.67158D-05   0.58350D-02   0.11492D-04
S1 Engine No:4 -Y-Z               1154    -0.58067D-02  -0.22653D-04   0.80590D-01  -0.10378D-05   0.58714D-02   0.12341D-04
S1 Engine No:5 -Y+Z               1155     0.58152D-02  -0.15771D-04   0.80590D-01  -0.12808D-05   0.58716D-02  -0.89446D-05
S1 Engine No:6 -Y+Z               1156     0.14019D-01  -0.19041D-04   0.80597D-01   0.73584D-05   0.58348D-02  -0.76537D-05
S1 Engine No:7 +Y+Z               1157     0.14015D-01  -0.18951D-04   0.80597D-01  -0.71932D-05   0.58348D-02   0.11324D-04
S1 Engine No:8 +Y+Z               1158     0.58067D-02  -0.22591D-04   0.80590D-01   0.77198D-06   0.58714D-02   0.12310D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01  -0.59874D-07   0.55176D-02   0.14255D-05
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01  -0.59874D-07   0.55176D-02   0.14255D-05
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01  -0.59874D-07   0.55176D-02   0.14255D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01
Stage-2 Tank Top, IMU Locat.     40015     0.75883D-08   0.26906D-05  -0.10707D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.11194D-07  -0.16238D-04   0.52694D-01  -0.76328D-07  -0.99685D-03  -0.17519D-06
Fuel Slosh Mass Locat.             600     0.16082D-07   0.14572D-04  -0.47540D-01  -0.89460D-07   0.17190D-04  -0.21182D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.88496D-07  -0.26002D-04   0.83710D-01  -0.55020D-04   0.82306D-02   0.58724D-05

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    50.988       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.15330D-01   0.86878D-01   0.25245D-04  -0.83622D-05   0.12166D-04  -0.63998D-02
S1 Engine No:2 +Y-Z               1152     0.63254D-02   0.86870D-01   0.29642D-04   0.96854D-06   0.13128D-04  -0.64420D-02
S1 Engine No:3 -Y-Z               1153    -0.64260D-02   0.86870D-01   0.22333D-04   0.78264D-06  -0.97150D-05  -0.64418D-02
S1 Engine No:4 -Y-Z               1154    -0.15427D-01   0.86878D-01   0.26635D-04  -0.77536D-05  -0.95665D-05  -0.63998D-02
S1 Engine No:5 -Y+Z               1155    -0.15425D-01   0.86876D-01   0.26486D-04   0.87222D-05   0.11758D-04  -0.64004D-02
S1 Engine No:6 -Y+Z               1156    -0.64188D-02   0.86869D-01   0.29714D-04  -0.20171D-05   0.13628D-04  -0.64423D-02
S1 Engine No:7 +Y+Z               1157     0.63332D-02   0.86869D-01   0.21018D-04  -0.13366D-05  -0.10345D-04  -0.64420D-02
S1 Engine No:8 +Y+Z               1158     0.15334D-01   0.86877D-01   0.25266D-04   0.90170D-05  -0.87638D-05  -0.63998D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05  -0.49861D-07   0.15511D-05  -0.53716D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05  -0.49861D-07   0.15511D-05  -0.53716D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05  -0.49861D-07   0.15511D-05  -0.53716D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.12783D-04  -0.85522D-02  -0.25489D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.24363D-04   0.58718D-01   0.13419D-04  -0.42239D-07  -0.34873D-06   0.83621D-03
Fuel Slosh Mass Locat.             600    -0.41249D-04  -0.51680D-01  -0.11729D-04  -0.21478D-07   0.21264D-06   0.18689D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.19907D-03   0.90567D-01   0.19297D-04   0.10513D-03  -0.25526D-05  -0.92272D-02

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    53.995       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.32957D-02   0.13441D-04   0.43432D-01   0.55919D-06   0.33313D-02  -0.70805D-05
S1 Engine No:2 +Y-Z               1152    -0.79525D-02   0.11527D-04   0.43436D-01  -0.40969D-05   0.33085D-02  -0.67261D-05
S1 Engine No:3 -Y-Z               1153    -0.79539D-02   0.11722D-04   0.43436D-01   0.44260D-05   0.33085D-02   0.53218D-05
S1 Engine No:4 -Y-Z               1154    -0.32989D-02   0.96389D-05   0.43432D-01  -0.53737D-06   0.33313D-02   0.58553D-05
S1 Engine No:5 -Y+Z               1155     0.32959D-02   0.13768D-04   0.43432D-01  -0.68957D-06   0.33314D-02  -0.71707D-05
S1 Engine No:6 -Y+Z               1156     0.79525D-02   0.11486D-04   0.43436D-01   0.48414D-05   0.33084D-02  -0.63750D-05
S1 Engine No:7 +Y+Z               1157     0.79536D-02   0.11571D-04   0.43436D-01  -0.44732D-05   0.33084D-02   0.52132D-05
S1 Engine No:8 +Y+Z               1158     0.32989D-02   0.94194D-05   0.43432D-01   0.62680D-06   0.33313D-02   0.58350D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02  -0.22952D-07   0.19405D-02  -0.58346D-06
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02  -0.22952D-07   0.19405D-02  -0.58346D-06
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02  -0.22952D-07   0.19405D-02  -0.58346D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02
Stage-2 Tank Top, IMU Locat.     40015     0.10932D-10  -0.57461D-06  -0.17959D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10917D-08   0.59514D-05   0.30128D-01   0.93208D-08  -0.12114D-03   0.12337D-06
Fuel Slosh Mass Locat.             600    -0.28225D-08  -0.49153D-05  -0.26139D-01   0.58660D-07  -0.29987D-03  -0.94716D-07

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.44869D-07   0.72636D-05   0.45500D-01  -0.36629D-04   0.48913D-02   0.20015D-05

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.683       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.77430D-02   0.32333D-01  -0.15578D-03  -0.69110D-05  -0.10335D-04  -0.31972D-02
S1 Engine No:2 +Y-Z               1152     0.32590D-02   0.32326D-01  -0.15218D-03   0.93539D-06  -0.96658D-05  -0.32274D-02
S1 Engine No:3 -Y-Z               1153    -0.31316D-02   0.32326D-01  -0.15827D-03   0.70309D-06  -0.22667D-04  -0.32273D-02
S1 Engine No:4 -Y-Z               1154    -0.76613D-02   0.32332D-01  -0.15469D-03  -0.63479D-05  -0.22914D-04  -0.31969D-02
S1 Engine No:5 -Y+Z               1155    -0.76948D-02   0.32331D-01  -0.15509D-03   0.74357D-05  -0.10613D-04  -0.31975D-02
S1 Engine No:6 -Y+Z               1156    -0.32099D-02   0.32324D-01  -0.15229D-03  -0.17125D-05  -0.89902D-05  -0.32278D-02
S1 Engine No:7 +Y+Z               1157     0.31813D-02   0.32324D-01  -0.15929D-03  -0.10157D-05  -0.23010D-04  -0.32275D-02
S1 Engine No:8 +Y+Z               1158     0.77111D-02   0.32332D-01  -0.15549D-03   0.76890D-05  -0.22082D-04  -0.31973D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03  -0.11856D-06   0.33664D-04   0.67061D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03  -0.11856D-06   0.33664D-04   0.67061D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03  -0.11856D-06   0.33664D-04   0.67061D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.42522D-05  -0.40513D-01   0.20329D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.74179D-05  -0.58567D-02   0.32349D-04  -0.77764D-07  -0.15433D-04  -0.30749D-02
Fuel Slosh Mass Locat.             600     0.22403D-04  -0.19267D-01   0.95590D-04   0.92743D-08   0.65914D-05   0.12486D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.16033D-03   0.36557D-01  -0.20016D-03   0.12786D-03  -0.48155D-04  -0.63548D-02

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.766       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.31253D-02   0.17076D-03   0.32081D-01   0.80204D-06   0.31951D-02  -0.22608D-04
S1 Engine No:2 +Y-Z               1152    -0.76103D-02   0.16787D-03   0.32087D-01  -0.60214D-05   0.31656D-02  -0.22450D-04
S1 Engine No:3 -Y-Z               1153    -0.76420D-02   0.16841D-03   0.32086D-01   0.65590D-05   0.31656D-02  -0.95069D-05
S1 Engine No:4 -Y-Z               1154    -0.32013D-02   0.16532D-03   0.32080D-01  -0.83570D-06   0.31951D-02  -0.87563D-05
S1 Engine No:5 -Y+Z               1155     0.31259D-02   0.17128D-03   0.32080D-01  -0.10049D-05   0.31955D-02  -0.22751D-04
S1 Engine No:6 -Y+Z               1156     0.76107D-02   0.16780D-03   0.32087D-01   0.72080D-05   0.31655D-02  -0.21888D-04
S1 Engine No:7 +Y+Z               1157     0.76418D-02   0.16816D-03   0.32088D-01  -0.66332D-05   0.31654D-02  -0.96786D-05
S1 Engine No:8 +Y+Z               1158     0.32015D-02   0.16496D-03   0.32081D-01   0.97784D-06   0.31951D-02  -0.87920D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01  -0.95857D-07  -0.66751D-02   0.33552D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01  -0.95857D-07  -0.66751D-02   0.33552D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01  -0.95857D-07  -0.66751D-02   0.33552D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.41615D-07  -0.20459D-03  -0.40687D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.22458D-07  -0.26901D-04  -0.59334D-02  -0.11330D-07   0.30594D-02  -0.15379D-04
Fuel Slosh Mass Locat.             600     0.11036D-06  -0.97010D-04  -0.19081D-01   0.97547D-07  -0.12340D-02   0.58794D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.75747D-07   0.16447D-03   0.35977D-01  -0.72496D-04   0.60902D-02  -0.14819D-04

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    98.803       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.28567D-01   0.89020D-01  -0.72209D-02  -0.25456D-04  -0.93281D-03  -0.11512D-01
S1 Engine No:2 +Y-Z               1152     0.13670D-01   0.88996D-01  -0.72151D-02   0.12635D-04  -0.92252D-03  -0.11623D-01
S1 Engine No:3 -Y-Z               1153    -0.93417D-02   0.88996D-01  -0.72538D-02   0.71268D-05  -0.94780D-03  -0.11625D-01
S1 Engine No:4 -Y-Z               1154    -0.26875D-01   0.89021D-01  -0.72436D-02  -0.22033D-04  -0.95899D-03  -0.11514D-01
S1 Engine No:5 -Y+Z               1155    -0.28751D-01   0.88997D-01  -0.72469D-02   0.40658D-04  -0.93496D-03  -0.11515D-01
S1 Engine No:6 -Y+Z               1156    -0.13850D-01   0.88959D-01  -0.72279D-02  -0.44970D-05  -0.92051D-03  -0.11626D-01
S1 Engine No:7 +Y+Z               1157     0.91652D-02   0.88959D-01  -0.72471D-02   0.38098D-05  -0.95077D-03  -0.11625D-01
S1 Engine No:8 +Y+Z               1158     0.26699D-01   0.89004D-01  -0.72182D-02   0.41219D-04  -0.95544D-03  -0.11515D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03  -0.75408D-05   0.55742D-04   0.68892D-03
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03  -0.75408D-05   0.55742D-04   0.68892D-03
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03  -0.75408D-05   0.55742D-04   0.68892D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03
Stage-2 Tank Top, IMU Locat.     40015     0.97780D-04   0.86306D-02  -0.69925D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.55070D-04  -0.92059D-02   0.74749D-03  -0.31501D-05  -0.88537D-04  -0.10899D-02
Fuel Slosh Mass Locat.             600    -0.24521D-04  -0.41341D-01   0.33607D-02   0.30340D-05   0.34400D-03   0.42319D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.15721D-02   0.12047D+00  -0.97938D-02   0.10663D-02  -0.27991D-02  -0.34440D-01

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    99.014       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.93336D-02   0.73877D-02   0.90708D-01  -0.55645D-06   0.11719D-01  -0.95914D-03
S1 Engine No:2 +Y-Z               1152    -0.27014D-01   0.73689D-02   0.90742D-01  -0.29412D-04   0.11608D-01  -0.96830D-03
S1 Engine No:3 -Y-Z               1153    -0.28902D-01   0.73729D-02   0.90740D-01   0.28934D-04   0.11606D-01  -0.93811D-03
S1 Engine No:4 -Y-Z               1154    -0.13879D-01   0.73635D-02   0.90713D-01  -0.81139D-05   0.11718D-01  -0.92722D-03
S1 Engine No:5 -Y+Z               1155     0.93224D-02   0.73935D-02   0.90712D-01  -0.40928D-05   0.11721D-01  -0.96006D-03
S1 Engine No:6 -Y+Z               1156     0.27002D-01   0.73771D-02   0.90744D-01   0.31358D-04   0.11608D-01  -0.96557D-03
S1 Engine No:7 +Y+Z               1157     0.28887D-01   0.73803D-02   0.90742D-01  -0.33253D-04   0.11605D-01  -0.93900D-03
S1 Engine No:8 +Y+Z               1158     0.13866D-01   0.73651D-02   0.90708D-01   0.54815D-05   0.11718D-01  -0.92743D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02   0.13378D-05  -0.69455D-03   0.56732D-04
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02   0.13378D-05  -0.69455D-03   0.56732D-04
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02   0.13378D-05  -0.69455D-03   0.56732D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02
Stage-2 Tank Top, IMU Locat.     40015     0.68452D-05   0.69613D-03   0.85337D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.38678D-05  -0.73731D-03  -0.90582D-02   0.56479D-06   0.11043D-02  -0.89848D-04
Fuel Slosh Mass Locat.             600    -0.16951D-05  -0.34148D-02  -0.42003D-01  -0.53178D-06  -0.42436D-02   0.34501D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.10928D-03   0.95353D-02   0.11727D+00  -0.46031D-03   0.31105D-01  -0.25321D-02

MODE# 11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    102.26       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.92163D-05   0.22601D-01   0.54644D-01   0.22891D-01   0.84820D-06   0.38878D-05
S1 Engine No:2 +Y-Z               1152    -0.55848D-05   0.54606D-01   0.22639D-01   0.22891D-01   0.33014D-06   0.33446D-05
S1 Engine No:3 -Y-Z               1153     0.80772D-06   0.54606D-01  -0.22623D-01   0.22891D-01   0.14764D-05   0.33539D-05
S1 Engine No:4 -Y-Z               1154     0.69195D-05   0.22601D-01  -0.54628D-01   0.22891D-01   0.92426D-06   0.38308D-05
S1 Engine No:5 -Y+Z               1155     0.84918D-05  -0.22661D-01  -0.54628D-01   0.22891D-01   0.90648D-06   0.27097D-05
S1 Engine No:6 -Y+Z               1156     0.52666D-05  -0.54666D-01  -0.22623D-01   0.22891D-01   0.13944D-05   0.33220D-05
S1 Engine No:7 +Y+Z               1157    -0.15504D-05  -0.54666D-01   0.22639D-01   0.22891D-01   0.30354D-06   0.33161D-05
S1 Engine No:8 +Y+Z               1158    -0.72555D-05  -0.22661D-01   0.54644D-01   0.22891D-01   0.88757D-06   0.27700D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05  -0.28561D-01  -0.34303D-06  -0.20275D-06
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05  -0.28561D-01  -0.34303D-06  -0.20275D-06
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05  -0.28561D-01  -0.34303D-06  -0.20275D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05
Stage-2 Tank Top, IMU Locat.     40015     0.24697D-06  -0.19195D-05   0.35735D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.12519D-06   0.16611D-05  -0.12105D-05  -0.10382D-01   0.14159D-06   0.34177D-06
Fuel Slosh Mass Locat.             600    -0.84227D-07   0.13478D-04  -0.36743D-05   0.12420D-01  -0.31908D-06  -0.11187D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.28565D-05  -0.92126D-05  -0.31152D-05   0.26162D-01  -0.10583D-04  -0.14358D-04

MODE# 12/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    109.98       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.36829D-05   0.15646D-01   0.37808D-01   0.15839D-01   0.32694D-06   0.15230D-05
S1 Engine No:2 +Y-Z               1152    -0.25167D-05   0.37791D-01   0.15663D-01   0.15839D-01  -0.85690D-07   0.10763D-05
S1 Engine No:3 -Y-Z               1153    -0.56940D-06   0.37791D-01  -0.15655D-01   0.15839D-01   0.83436D-06   0.10817D-05
S1 Engine No:4 -Y-Z               1154     0.15970D-05   0.15646D-01  -0.37800D-01   0.15839D-01   0.38783D-06   0.14722D-05
S1 Engine No:5 -Y+Z               1155     0.21558D-05  -0.15672D-01  -0.37800D-01   0.15839D-01   0.37084D-06   0.57247D-06
S1 Engine No:6 -Y+Z               1156     0.13173D-05  -0.37817D-01  -0.15655D-01   0.15839D-01   0.76304D-06   0.10561D-05
S1 Engine No:7 +Y+Z               1157    -0.97148D-06  -0.37817D-01   0.15663D-01   0.15839D-01  -0.11196D-06   0.10540D-05
S1 Engine No:8 +Y+Z               1158    -0.28103D-05  -0.15672D-01   0.37808D-01   0.15839D-01   0.35693D-06   0.62642D-06

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05  -0.19726D-01   0.79814D-06  -0.37598D-07
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05  -0.19726D-01   0.79814D-06  -0.37598D-07
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05  -0.19726D-01   0.79814D-06  -0.37598D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05
Stage-2 Tank Top, IMU Locat.     40015     0.70868D-06  -0.32549D-06  -0.41273D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.30837D-06  -0.33980D-06   0.28099D-05  -0.79243D-02  -0.13068D-06   0.13364D-06
Fuel Slosh Mass Locat.             600    -0.30723D-06   0.59627D-05  -0.21820D-05   0.75040D-02  -0.62951D-07  -0.30580D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.36268D-05   0.19274D-04  -0.98857D-05   0.18522D-01  -0.12389D-04  -0.24172D-04

MODE# 13/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    124.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.21235D-02  -0.66494D-02  -0.80960D-05   0.37308D-05   0.11405D-04   0.96781D-03
S1 Engine No:2 +Y-Z               1152    -0.77494D-03  -0.66454D-02  -0.10086D-04  -0.61187D-06   0.10725D-04   0.98023D-03
S1 Engine No:3 -Y-Z               1153     0.11666D-02  -0.66455D-02  -0.67337D-05  -0.49172D-06   0.11407D-04   0.98124D-03
S1 Engine No:4 -Y-Z               1154     0.25497D-02  -0.66493D-02  -0.86242D-05   0.33469D-05   0.12412D-04   0.97049D-03
S1 Engine No:5 -Y+Z               1155     0.25749D-02  -0.66480D-02  -0.80903D-05  -0.42072D-05   0.12978D-04   0.97116D-03
S1 Engine No:6 -Y+Z               1156     0.12258D-02  -0.66441D-02  -0.97536D-05   0.92756D-06   0.13446D-04   0.98180D-03
S1 Engine No:7 +Y+Z               1157    -0.71618D-03  -0.66441D-02  -0.61132D-05   0.56344D-06   0.14760D-04   0.97998D-03
S1 Engine No:8 +Y+Z               1158    -0.20993D-02  -0.66485D-02  -0.84301D-05  -0.44021D-05   0.13262D-04   0.96755D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03  -0.25290D-05  -0.24515D-03  -0.14803D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03  -0.25290D-05  -0.24515D-03  -0.14803D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03  -0.25290D-05  -0.24515D-03  -0.14803D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.24912D-03  -0.16432D-01   0.27012D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.13168D-03   0.61922D-01  -0.10506D-02  -0.34141D-06   0.50370D-04   0.31469D-02
Fuel Slosh Mass Locat.             600     0.73772D-04  -0.67523D-02   0.18941D-03   0.74642D-06  -0.22272D-04  -0.13788D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.12818D-02  -0.26849D-01   0.10777D-02  -0.73744D-03   0.77426D-03   0.15258D-01

MODE# 14/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    124.98       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.10054D-02   0.27377D-03   0.85836D-02   0.71408D-06   0.10586D-02  -0.24233D-04
S1 Engine No:2 +Y-Z               1152    -0.25115D-02   0.27183D-03   0.85879D-02  -0.40939D-05   0.10407D-02  -0.25002D-04
S1 Engine No:3 -Y-Z               1153    -0.25560D-02   0.27236D-03   0.85867D-02   0.49964D-05   0.10404D-02  -0.19697D-04
S1 Engine No:4 -Y-Z               1154    -0.11119D-02   0.26990D-03   0.85818D-02  -0.56899D-06   0.10583D-02  -0.18710D-04
S1 Engine No:5 -Y+Z               1155     0.98598D-03   0.27374D-03   0.85817D-02  -0.42271D-06   0.10588D-02  -0.24480D-04
S1 Engine No:6 -Y+Z               1156     0.24919D-02   0.27071D-03   0.85873D-02   0.54546D-05   0.10405D-02  -0.24622D-04
S1 Engine No:7 +Y+Z               1157     0.25360D-02   0.27110D-03   0.85881D-02  -0.46181D-05   0.10400D-02  -0.19768D-04
S1 Engine No:8 +Y+Z               1158     0.10923D-02   0.26916D-03   0.85836D-02   0.11253D-05   0.10583D-02  -0.18611D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01  -0.89614D-06  -0.14921D-01   0.26010D-03
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01  -0.89614D-06  -0.14921D-01   0.26010D-03
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01  -0.89614D-06  -0.14921D-01   0.26010D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01
Stage-2 Tank Top, IMU Locat.     40015     0.12498D-04   0.28582D-03   0.16277D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.45497D-05  -0.10555D-02  -0.62061D-01  -0.24227D-06   0.31890D-02  -0.57407D-04
Fuel Slosh Mass Locat.             600    -0.58588D-05   0.18085D-04   0.56575D-02   0.29372D-06  -0.14039D-02   0.25016D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.22007D-04  -0.35657D-03   0.17478D-01  -0.21676D-03   0.74215D-02   0.41430D-03

MODE# 15/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.71213D-03   0.23185D-01  -0.19308D-02  -0.34428D-04   0.37868D-04   0.11625D-03
S1 Engine No:2 +Y-Z               1152    -0.71683D-03   0.23146D-01  -0.18986D-02  -0.14257D-04   0.52560D-04   0.43510D-05
S1 Engine No:3 -Y-Z               1153    -0.76069D-03   0.23147D-01  -0.18796D-02  -0.17138D-04  -0.24212D-04  -0.63103D-05
S1 Engine No:4 -Y-Z               1154    -0.76744D-03   0.23186D-01  -0.18456D-02  -0.32970D-04  -0.34543D-04   0.99049D-04
S1 Engine No:5 -Y+Z               1155    -0.77361D-03   0.23217D-01  -0.18441D-02  -0.55244D-06   0.32262D-04   0.10430D-03
S1 Engine No:6 -Y+Z               1156    -0.76727D-03   0.23229D-01  -0.18637D-02  -0.23088D-04   0.42328D-04  -0.12968D-05
S1 Engine No:7 +Y+Z               1157    -0.72221D-03   0.23229D-01  -0.19175D-02  -0.19388D-04  -0.36178D-04  -0.15797D-05
S1 Engine No:8 +Y+Z               1158    -0.71548D-03   0.23220D-01  -0.19330D-02  -0.39323D-06  -0.38087D-04   0.10992D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03  -0.33755D-04   0.19580D-03   0.23651D-02
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03  -0.33755D-04   0.19580D-03   0.23651D-02
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03  -0.33755D-04   0.19580D-03   0.23651D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03
Stage-2 Tank Top, IMU Locat.     40015     0.13049D-02   0.14184D-02  -0.11661D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.27366D-03  -0.31661D-03   0.40432D-04  -0.13052D-05  -0.77944D-04  -0.95042D-03
Fuel Slosh Mass Locat.             600    -0.75579D-03  -0.19256D-01   0.15644D-02   0.51198D-05   0.15161D-05   0.13934D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.11034D-01  -0.19873D+00   0.16150D-01  -0.85100D-02   0.12640D-01   0.15558D+00

MODE# 16/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    141.94       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.12461D-04  -0.27903D-01  -0.67393D-01  -0.28211D-01   0.25075D-04  -0.59590D-05
S1 Engine No:2 +Y-Z               1152    -0.54460D-04  -0.67347D-01  -0.27949D-01  -0.28211D-01   0.27140D-04  -0.43987D-05
S1 Engine No:3 -Y-Z               1153    -0.63286D-04  -0.67347D-01   0.27835D-01  -0.28211D-01   0.24582D-04  -0.52024D-05
S1 Engine No:4 -Y-Z               1154    -0.35623D-04  -0.27903D-01   0.67280D-01  -0.28211D-01   0.25090D-04  -0.66590D-05
S1 Engine No:5 -Y+Z               1155     0.14031D-04   0.27881D-01   0.67280D-01  -0.28211D-01   0.24944D-04  -0.31180D-05
S1 Engine No:6 -Y+Z               1156     0.55024D-04   0.67326D-01   0.27835D-01  -0.28211D-01   0.24578D-04  -0.43500D-05
S1 Engine No:7 +Y+Z               1157     0.64894D-04   0.67326D-01  -0.27949D-01  -0.28211D-01   0.27410D-04  -0.51197D-05
S1 Engine No:8 +Y+Z               1158     0.36228D-04   0.27881D-01  -0.67393D-01  -0.28211D-01   0.25169D-04  -0.41076D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05  -0.20324D-01   0.27256D-04  -0.51688D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05  -0.20324D-01   0.27256D-04  -0.51688D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05  -0.20324D-01   0.27256D-04  -0.51688D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.20387D-05   0.14400D-05   0.76338D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.17548D-06  -0.25717D-04  -0.13441D-03   0.23504D-02  -0.12887D-04   0.24521D-05
Fuel Slosh Mass Locat.             600     0.11767D-05   0.49652D-04   0.26051D-03  -0.41432D-02  -0.10219D-04   0.19501D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.24483D-04   0.53017D-03   0.28636D-02  -0.37313D-01   0.20872D-02  -0.37598D-03

MODE# 17/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    142.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.18382D-02   0.19528D-04  -0.29754D-02   0.33061D-03   0.23525D-02  -0.16008D-03
S1 Engine No:2 +Y-Z               1152    -0.53760D-02   0.48403D-03  -0.34395D-02   0.33527D-03   0.24244D-02  -0.15680D-03
S1 Engine No:3 -Y-Z               1153    -0.57516D-02   0.48724D-03  -0.40936D-02   0.32672D-03   0.24304D-02  -0.22596D-03
S1 Engine No:4 -Y-Z               1154    -0.27455D-02   0.25956D-04  -0.45554D-02   0.33202D-03   0.23581D-02  -0.23428D-03
S1 Engine No:5 -Y+Z               1155     0.18775D-02  -0.63485D-03  -0.45557D-02   0.33131D-03   0.23527D-02  -0.15980D-03
S1 Engine No:6 -Y+Z               1156     0.54152D-02  -0.10961D-02  -0.40940D-02   0.32696D-03   0.24247D-02  -0.15652D-03
S1 Engine No:7 +Y+Z               1157     0.57907D-02  -0.10929D-02  -0.34388D-02   0.33521D-03   0.24306D-02  -0.22615D-03
S1 Engine No:8 +Y+Z               1158     0.27847D-02  -0.62863D-03  -0.29751D-02   0.32998D-03   0.23584D-02  -0.23467D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03   0.23040D-03   0.24800D-02  -0.20040D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03   0.23040D-03   0.24800D-02  -0.20040D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03   0.23040D-03   0.24800D-02  -0.20040D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.94692D-04   0.65066D-04   0.80984D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.73494D-05  -0.10477D-02  -0.12851D-01  -0.28549D-04  -0.11730D-02   0.95112D-04
Fuel Slosh Mass Locat.             600     0.54603D-04   0.18992D-02   0.23385D-01   0.52355D-04  -0.97679D-03   0.79457D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.11485D-02   0.20580D-01   0.25313D+00  -0.48914D-02   0.18290D+00  -0.14892D-01

MODE# 18/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    152.45       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11892D-01  -0.35979D-01   0.28838D-02   0.24738D-04   0.37788D-03   0.46991D-02
S1 Engine No:2 +Y-Z               1152    -0.57499D-02  -0.35956D-01   0.28780D-02  -0.12660D-04   0.36934D-03   0.48058D-02
S1 Engine No:3 -Y-Z               1153     0.37788D-02  -0.35956D-01   0.29168D-02  -0.72998D-05   0.38884D-03   0.48064D-02
S1 Engine No:4 -Y-Z               1154     0.10999D-01  -0.35980D-01   0.29069D-02   0.21133D-04   0.40006D-03   0.46987D-02
S1 Engine No:5 -Y+Z               1155     0.11773D-01  -0.35956D-01   0.29100D-02  -0.40391D-04   0.37931D-03   0.47000D-02
S1 Engine No:6 -Y+Z               1156     0.56259D-02  -0.35918D-01   0.28909D-02   0.47176D-05   0.36520D-03   0.48073D-02
S1 Engine No:7 +Y+Z               1157    -0.39065D-02  -0.35918D-01   0.29104D-02  -0.37284D-05   0.38974D-03   0.48077D-02
S1 Engine No:8 +Y+Z               1158    -0.11126D-01  -0.35963D-01   0.28813D-02  -0.41002D-04   0.39529D-03   0.47010D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03  -0.28853D-05   0.52696D-03   0.65227D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03  -0.28853D-05   0.52696D-03   0.65227D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03  -0.28853D-05   0.52696D-03   0.65227D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.12504D-03  -0.76350D-02   0.61730D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.25304D-04   0.63941D-01  -0.51509D-02   0.80276D-06  -0.23174D-03  -0.28733D-02
Fuel Slosh Mass Locat.             600     0.71781D-04  -0.33165D-01   0.26740D-02  -0.21484D-05  -0.33730D-03  -0.41854D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.20684D-02  -0.17526D-02   0.16739D-03   0.14513D-02  -0.14756D-02  -0.18553D-01

MODE# 19/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    152.95       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.33807D-02   0.28071D-02   0.34733D-01  -0.64511D-05   0.42377D-02  -0.34956D-03
S1 Engine No:2 +Y-Z               1152    -0.97497D-02   0.27804D-02   0.34773D-01  -0.34105D-04   0.41262D-02  -0.35888D-03
S1 Engine No:3 -Y-Z               1153    -0.10428D-01   0.27836D-02   0.34783D-01   0.21301D-04   0.41240D-02  -0.32474D-03
S1 Engine No:4 -Y-Z               1154    -0.50081D-02   0.27831D-02   0.34766D-01  -0.14297D-04   0.42356D-02  -0.31417D-03
S1 Engine No:5 -Y+Z               1155     0.34010D-02   0.28251D-02   0.34766D-01  -0.10431D-04   0.42391D-02  -0.35015D-03
S1 Engine No:6 -Y+Z               1156     0.97690D-02   0.28181D-02   0.34787D-01   0.23611D-04   0.41261D-02  -0.35609D-03
S1 Engine No:7 +Y+Z               1157     0.10445D-01   0.28204D-02   0.34773D-01  -0.37844D-04   0.41228D-02  -0.32567D-03
S1 Engine No:8 +Y+Z               1158     0.50270D-02   0.27970D-02   0.34733D-01  -0.83634D-06   0.42360D-02  -0.31466D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02  -0.30602D-05   0.62605D-02  -0.50336D-03
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02  -0.30602D-05   0.62605D-02  -0.50336D-03
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02  -0.30602D-05   0.62605D-02  -0.50336D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02
Stage-2 Tank Top, IMU Locat.     40015     0.27916D-04   0.61098D-03   0.76042D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.31560D-05  -0.50504D-02  -0.62643D-01   0.87187D-06  -0.27324D-02   0.22004D-03
Fuel Slosh Mass Locat.             600    -0.14945D-04   0.24073D-02   0.29884D-01  -0.23658D-05  -0.40441D-02   0.32594D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.40165D-03  -0.38802D-02  -0.47747D-01   0.18056D-02  -0.53114D-01   0.43108D-02

MODE# 20/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    210.43       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.22607D-02  -0.34961D-01   0.11248D-02   0.71316D-04  -0.17231D-03  -0.14842D-02
S1 Engine No:2 +Y-Z               1152     0.90184D-03  -0.34904D-01   0.10902D-02  -0.13807D-04  -0.19798D-03  -0.10029D-02
S1 Engine No:3 -Y-Z               1153    -0.88603D-03  -0.34904D-01   0.11653D-02  -0.84346D-05   0.14447D-03  -0.99466D-03
S1 Engine No:4 -Y-Z               1154    -0.22767D-02  -0.34962D-01   0.11283D-02   0.66210D-04   0.15280D-03  -0.14762D-02
S1 Engine No:5 -Y+Z               1155    -0.22857D-02  -0.34946D-01   0.11169D-02  -0.74880D-04  -0.16961D-03  -0.14814D-02
S1 Engine No:6 -Y+Z               1156    -0.93384D-03  -0.34894D-01   0.10898D-02   0.21516D-04  -0.20263D-03  -0.99988D-03
S1 Engine No:7 +Y+Z               1157     0.84812D-03  -0.34895D-01   0.11753D-02   0.11817D-04   0.14666D-03  -0.99304D-03
S1 Engine No:8 +Y+Z               1158     0.22393D-02  -0.34956D-01   0.11370D-02  -0.76158D-04   0.14616D-03  -0.14743D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03  -0.77153D-07   0.61160D-04   0.22748D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03  -0.77153D-07   0.61160D-04   0.22748D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03  -0.77153D-07   0.61160D-04   0.22748D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.33772D-03  -0.20923D-01   0.56227D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.49354D-04   0.92765D-01  -0.25208D-02   0.10276D-06   0.55102D-04   0.20428D-02
Fuel Slosh Mass Locat.             600     0.51676D-04   0.77563D-01  -0.21194D-02  -0.63973D-06   0.58211D-05   0.31410D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.85876D-03  -0.25385D-01   0.10102D-02   0.69814D-03  -0.49517D-04  -0.62779D-02

MODE# 21/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    219.71       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.42877D-01   0.20936D+00  -0.16374D-01  -0.45854D-03  -0.99936D-03  -0.15667D-01
S1 Engine No:2 +Y-Z               1152     0.20477D-01   0.20894D+00  -0.16152D-01   0.10380D-03  -0.82160D-03  -0.17623D-01
S1 Engine No:3 -Y-Z               1153    -0.15029D-01   0.20894D+00  -0.16576D-01   0.28703D-04  -0.16043D-02  -0.17688D-01
S1 Engine No:4 -Y-Z               1154    -0.41247D-01   0.20938D+00  -0.16304D-01  -0.40650D-03  -0.17881D-02  -0.15744D-01
S1 Engine No:5 -Y+Z               1155    -0.44106D-01   0.20923D+00  -0.16295D-01   0.48890D-03  -0.10383D-02  -0.15721D-01
S1 Engine No:6 -Y+Z               1156    -0.21642D-01   0.20886D+00  -0.16145D-01  -0.17940D-03  -0.80996D-03  -0.17666D-01
S1 Engine No:7 +Y+Z               1157     0.13921D-01   0.20886D+00  -0.16674D-01  -0.61996D-04  -0.16528D-02  -0.17689D-01
S1 Engine No:8 +Y+Z               1158     0.40132D-01   0.20933D+00  -0.16392D-01   0.49404D-03  -0.17413D-02  -0.15731D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03   0.54136D-06   0.66563D-04   0.85902D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03   0.54136D-06   0.66563D-04   0.85902D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03   0.54136D-06   0.66563D-04   0.85902D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.45034D-03  -0.10312D-01   0.79885D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.17621D-03   0.40456D-01  -0.31847D-02  -0.79880D-06   0.89116D-04   0.11442D-02
Fuel Slosh Mass Locat.             600    -0.18985D-03   0.15971D-01  -0.12709D-02   0.54620D-05   0.30512D-03   0.38983D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.57091D-02   0.13648D+00  -0.10735D-01  -0.59984D-02   0.19040D-02   0.24833D-01

MODE# 22/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    220.78       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.14260D-01  -0.16573D-01  -0.20902D+00  -0.32758D-04  -0.17359D-01   0.16324D-02
S1 Engine No:2 +Y-Z               1152     0.40052D-01  -0.16332D-01  -0.20943D+00   0.39996D-03  -0.15421D-01   0.17801D-02
S1 Engine No:3 -Y-Z               1153     0.42800D-01  -0.16331D-01  -0.20936D+00  -0.42924D-03  -0.15361D-01   0.94445D-03
S1 Engine No:4 -Y-Z               1154     0.20735D-01  -0.16167D-01  -0.20900D+00   0.12173D-03  -0.17304D-01   0.76212D-03
S1 Engine No:5 -Y+Z               1155    -0.14166D-01  -0.16626D-01  -0.20900D+00   0.61967D-04  -0.17376D-01   0.16434D-02
S1 Engine No:6 -Y+Z               1156    -0.39941D-01  -0.16372D-01  -0.20943D+00  -0.45685D-03  -0.15413D-01   0.17437D-02
S1 Engine No:7 +Y+Z               1157    -0.42651D-01  -0.16360D-01  -0.20942D+00   0.45330D-03  -0.15340D-01   0.95303D-03
S1 Engine No:8 +Y+Z               1158    -0.20618D-01  -0.16159D-01  -0.20902D+00  -0.10994D-03  -0.17303D-01   0.76452D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01   0.42724D-06   0.80926D-03  -0.64013D-04
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01   0.42724D-06   0.80926D-03  -0.64013D-04
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01   0.42724D-06   0.80926D-03  -0.64013D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01
Stage-2 Tank Top, IMU Locat.     40015     0.40643D-04   0.79333D-03   0.10027D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.19149D-04  -0.30617D-02  -0.39352D-01  -0.58867D-06   0.11322D-02  -0.89065D-04
Fuel Slosh Mass Locat.             600     0.20949D-04  -0.10995D-02  -0.14307D-01   0.40781D-05   0.39462D-02  -0.30865D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.61726D-03  -0.83071D-02  -0.10704D+00  -0.43804D-02   0.45752D-01  -0.36334D-02

MODE# 23/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    261.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.21261D-01  -0.64181D-01   0.11109D-02   0.22396D-03   0.15100D-03   0.83526D-02
S1 Engine No:2 +Y-Z               1152    -0.92315D-02  -0.63953D-01   0.97763D-03  -0.36228D-04   0.14564D-03   0.89932D-02
S1 Engine No:3 -Y-Z               1153     0.86750D-02  -0.63954D-01   0.11677D-02  -0.23818D-04   0.14030D-03   0.89904D-02
S1 Engine No:4 -Y-Z               1154     0.21144D-01  -0.64174D-01   0.10344D-02   0.19877D-03   0.18707D-03   0.83512D-02
S1 Engine No:5 -Y+Z               1155     0.21509D-01  -0.64113D-01   0.10384D-02  -0.23106D-03   0.17051D-03   0.83764D-02
S1 Engine No:6 -Y+Z               1156     0.94428D-02  -0.63929D-01   0.96127D-03   0.91061D-04   0.13202D-03   0.90160D-02
S1 Engine No:7 +Y+Z               1157    -0.84996D-02  -0.63932D-01   0.12363D-02   0.55211D-04   0.15838D-03   0.89970D-02
S1 Engine No:8 +Y+Z               1158    -0.20963D-01  -0.64157D-01   0.11117D-02  -0.24002D-03   0.15511D-03   0.83503D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03  -0.20522D-06   0.75683D-05   0.52314D-03
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03  -0.20522D-06   0.75683D-05   0.52314D-03
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03  -0.20522D-06   0.75683D-05   0.52314D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03
Stage-2 Tank Top, IMU Locat.     40015     0.16624D-02  -0.37195D-01   0.54849D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.27790D-04   0.30279D-01  -0.51324D-03   0.48994D-06   0.60640D-04   0.40217D-02
Fuel Slosh Mass Locat.             600     0.71973D-04  -0.18694D-01   0.28561D-03  -0.47395D-05   0.56501D-05   0.19232D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.23224D-02  -0.42887D-01   0.12201D-02   0.51208D-02   0.31270D-03  -0.22892D-02

MODE# 24/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    262.16       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.85808D-02  -0.13379D-02  -0.65569D-01  -0.38444D-04  -0.89971D-02   0.17281D-03
S1 Engine No:2 +Y-Z               1152     0.21098D-01  -0.12365D-02  -0.65759D-01   0.18832D-03  -0.83521D-02   0.19936D-03
S1 Engine No:3 -Y-Z               1153     0.21434D-01  -0.12452D-02  -0.65728D-01  -0.21035D-03  -0.83532D-02   0.13391D-03
S1 Engine No:4 -Y-Z               1154     0.93566D-02  -0.11450D-02  -0.65532D-01   0.50437D-04  -0.90014D-02   0.12271D-03
S1 Engine No:5 -Y+Z               1155    -0.85914D-02  -0.13666D-02  -0.65531D-01   0.46493D-04  -0.90086D-02   0.17561D-03
S1 Engine No:6 -Y+Z               1156    -0.21096D-01  -0.12424D-02  -0.65754D-01  -0.23305D-03  -0.83471D-02   0.17618D-03
S1 Engine No:7 +Y+Z               1157    -0.21406D-01  -0.12447D-02  -0.65777D-01   0.21301D-03  -0.83424D-02   0.13795D-03
S1 Engine No:8 +Y+Z               1158    -0.93484D-02  -0.11329D-02  -0.65569D-01  -0.46646D-04  -0.89978D-02   0.12557D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01  -0.27002D-07  -0.40712D-03   0.92371D-05
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01  -0.27002D-07  -0.40712D-03   0.92371D-05
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01  -0.27002D-07  -0.40712D-03   0.92371D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01
Stage-2 Tank Top, IMU Locat.     40015     0.30687D-04  -0.67314D-03  -0.30268D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.21490D-05   0.52645D-03   0.27395D-01  -0.37864D-06  -0.33326D-02   0.72452D-04
Fuel Slosh Mass Locat.             600     0.36531D-05  -0.32282D-03  -0.14907D-01   0.39157D-05  -0.93865D-04  -0.41989D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.10042D-03  -0.18709D-03  -0.36066D-01  -0.41880D-02   0.80472D-02  -0.50588D-03

MODE# 25/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    280.29       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.11645D-03  -0.24325D-02  -0.34631D-02  -0.17093D-02  -0.37364D-04  -0.68699D-04
S1 Engine No:2 +Y-Z               1152     0.10048D-03  -0.48268D-02  -0.10673D-02  -0.17159D-02  -0.54259D-04  -0.47520D-04
S1 Engine No:3 -Y-Z               1153     0.25556D-04  -0.48272D-02   0.23241D-02  -0.17110D-02  -0.40642D-04  -0.36446D-04
S1 Engine No:4 -Y-Z               1154    -0.74725D-04  -0.24351D-02   0.47162D-02  -0.17106D-02  -0.23587D-04  -0.57211D-04
S1 Engine No:5 -Y+Z               1155    -0.12814D-03   0.95662D-03   0.47156D-02  -0.17167D-02  -0.37336D-04  -0.68244D-04
S1 Engine No:6 -Y+Z               1156    -0.11291D-03   0.33532D-02   0.23207D-02  -0.17092D-02  -0.55572D-04  -0.47348D-04
S1 Engine No:7 +Y+Z               1157    -0.38208D-04   0.33526D-02  -0.10632D-02  -0.17147D-02  -0.40319D-04  -0.36180D-04
S1 Engine No:8 +Y+Z               1158     0.61986D-04   0.95314D-03  -0.34625D-02  -0.17158D-02  -0.24132D-04  -0.56096D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03   0.37116D-04  -0.11368D-06  -0.14444D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03   0.37116D-04  -0.11368D-06  -0.14444D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03   0.37116D-04  -0.11368D-06  -0.14444D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.52423D-05  -0.15946D-03   0.14600D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.19587D-04  -0.17488D-03   0.12851D-03  -0.10242D-03   0.11065D-04   0.11303D-04
Fuel Slosh Mass Locat.             600    -0.28313D-04   0.31508D-03  -0.24718D-03   0.11174D-02  -0.46255D-04  -0.57086D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.61865D-03   0.61865D-02  -0.45493D-02  -0.11761D+01  -0.23862D-02  -0.36608D-02

MODE# 26/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    304.30       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.47553D-01  -0.10932D+00   0.46897D-02   0.58878D-03   0.11536D-02   0.18804D-01
S1 Engine No:2 +Y-Z               1152    -0.21913D-01  -0.10872D+00   0.43549D-02  -0.15020D-03   0.11612D-02   0.20009D-01
S1 Engine No:3 -Y-Z               1153     0.17670D-01  -0.10872D+00   0.49322D-02  -0.89892D-04   0.44773D-03   0.19967D-01
S1 Engine No:4 -Y-Z               1154     0.45640D-01  -0.10930D+00   0.45795D-02   0.49837D-03   0.64027D-03   0.18748D-01
S1 Engine No:5 -Y+Z               1155     0.47500D-01  -0.10903D+00   0.45878D-02  -0.67675D-03   0.12097D-02   0.18852D-01
S1 Engine No:6 -Y+Z               1156     0.21743D-01  -0.10849D+00   0.43529D-02   0.28170D-03   0.10935D-02   0.20083D-01
S1 Engine No:7 +Y+Z               1157    -0.17979D-01  -0.10851D+00   0.51148D-02   0.13412D-03   0.46477D-03   0.20008D-01
S1 Engine No:8 +Y+Z               1158    -0.45916D-01  -0.10919D+00   0.46959D-02  -0.69898D-03   0.51883D-03   0.18767D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03   0.14302D-06   0.30252D-05   0.39877D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03   0.14302D-06   0.30252D-05   0.39877D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03   0.14302D-06   0.30252D-05   0.39877D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.16579D-03   0.10095D-01  -0.48050D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.24007D-03   0.46444D-01  -0.19579D-02  -0.50350D-06   0.39479D-05   0.22093D-03
Fuel Slosh Mass Locat.             600     0.34807D-03  -0.70424D-01   0.30228D-02   0.62920D-05   0.25957D-03   0.59946D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.57454D-02  -0.73482D-01   0.35464D-02  -0.63234D-02   0.42734D-03   0.31930D-02

MODE# 27/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    304.61       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.17722D-01   0.50186D-02   0.10973D+00   0.87299D-04   0.19931D-01  -0.51650D-03
S1 Engine No:2 +Y-Z               1152    -0.45746D-01   0.46967D-02   0.11027D+00  -0.51232D-03   0.18764D-01  -0.64349D-03
S1 Engine No:3 -Y-Z               1153    -0.47493D-01   0.47206D-02   0.11021D+00   0.54569D-03   0.18799D-01  -0.11103D-02
S1 Engine No:4 -Y-Z               1154    -0.21776D-01   0.44915D-02   0.10972D+00  -0.19777D-03   0.19975D-01  -0.10923D-02
S1 Engine No:5 -Y+Z               1155     0.17797D-01   0.51568D-02   0.10972D+00  -0.15062D-03   0.19964D-01  -0.51920D-03
S1 Engine No:6 -Y+Z               1156     0.45774D-01   0.48218D-02   0.11031D+00   0.60485D-03   0.18749D-01  -0.57106D-03
S1 Engine No:7 +Y+Z               1157     0.47441D-01   0.48269D-02   0.11032D+00  -0.59462D-03   0.18764D-01  -0.11195D-02
S1 Engine No:8 +Y+Z               1158     0.21789D-01   0.44947D-02   0.10973D+00   0.13278D-03   0.19957D-01  -0.11055D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01  -0.31472D-07   0.68858D-04  -0.16626D-05
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01  -0.31472D-07   0.68858D-04  -0.16626D-05
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01  -0.31472D-07   0.68858D-04  -0.16626D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01
Stage-2 Tank Top, IMU Locat.     40015     0.41775D-05  -0.43116D-03  -0.11032D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.17384D-04  -0.20086D-02  -0.45515D-01  -0.30224D-06   0.10685D-03  -0.10156D-04
Fuel Slosh Mass Locat.             600    -0.24036D-04   0.30352D-02   0.70022D-01   0.45025D-05   0.59538D-02  -0.25583D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.37796D-03   0.22556D-02   0.61055D-01  -0.46010D-02  -0.60995D-02   0.55504D-03

MODE# 28/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    356.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.39662D-01  -0.82425D-01   0.92096D-03   0.87958D-03   0.81505D-03   0.16138D-01
S1 Engine No:2 +Y-Z               1152    -0.17249D-01  -0.81516D-01   0.32697D-03  -0.18968D-03   0.91697D-03   0.17570D-01
S1 Engine No:3 -Y-Z               1153     0.17374D-01  -0.81518D-01   0.11738D-02  -0.16594D-03  -0.66239D-03   0.17560D-01
S1 Engine No:4 -Y-Z               1154     0.40318D-01  -0.82327D-01   0.64649D-03   0.72036D-03  -0.34260D-03   0.16150D-01
S1 Engine No:5 -Y+Z               1155     0.40978D-01  -0.81894D-01   0.60956D-03  -0.10195D-02   0.96790D-03   0.16298D-01
S1 Engine No:6 -Y+Z               1156     0.18347D-01  -0.81146D-01   0.26334D-03   0.51419D-03   0.87994D-03   0.17784D-01
S1 Engine No:7 +Y+Z               1157    -0.16610D-01  -0.81169D-01   0.16217D-02   0.30125D-03  -0.60150D-03   0.17634D-01
S1 Engine No:8 +Y+Z               1158    -0.39444D-01  -0.82174D-01   0.98980D-03  -0.10869D-02  -0.55811D-03   0.16091D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04   0.35855D-07   0.11136D-04   0.12010D-02
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04   0.35855D-07   0.11136D-04   0.12010D-02
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04   0.35855D-07   0.11136D-04   0.12010D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04
Stage-2 Tank Top, IMU Locat.     40015     0.16267D-03   0.64381D-02  -0.39234D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.43877D-03  -0.10410D+00   0.11331D-02  -0.85159D-07  -0.38251D-04  -0.37780D-02
Fuel Slosh Mass Locat.             600    -0.35580D-03   0.26309D-01  -0.32066D-03   0.15287D-05   0.48175D-04   0.45547D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.56774D-02  -0.55789D-01   0.11930D-02  -0.13264D-02   0.52126D-03   0.76382D-02

MODE# 29/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    357.28       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.16964D-01   0.13169D-02   0.82771D-01   0.21761D-03   0.17686D-01   0.50860D-03
S1 Engine No:2 +Y-Z               1152    -0.40262D-01   0.88439D-03   0.83499D-01  -0.73486D-03   0.16351D-01   0.33959D-03
S1 Engine No:3 -Y-Z               1153    -0.40737D-01   0.87026D-03   0.83368D-01   0.82846D-03   0.16375D-01  -0.80413D-03
S1 Engine No:4 -Y-Z               1154    -0.17948D-01   0.49007D-03   0.82650D-01  -0.33751D-03   0.17758D-01  -0.86722D-03
S1 Engine No:5 -Y+Z               1155     0.17085D-01   0.16032D-02   0.82654D-01  -0.28904D-03   0.17744D-01   0.52810D-03
S1 Engine No:6 -Y+Z               1156     0.40259D-01   0.10716D-02   0.83535D-01   0.95326D-03   0.16309D-01   0.48263D-03
S1 Engine No:7 +Y+Z               1157     0.40556D-01   0.10241D-02   0.83653D-01  -0.86422D-03   0.16307D-01  -0.79952D-03
S1 Engine No:8 +Y+Z               1158     0.17912D-01   0.46482D-03   0.82777D-01   0.18740D-03   0.17682D-01  -0.89956D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02   0.41731D-06   0.10431D-02  -0.13205D-04
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02   0.41731D-06   0.10431D-02  -0.13205D-04
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02   0.41731D-06   0.10431D-02  -0.13205D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02
Stage-2 Tank Top, IMU Locat.     40015     0.36282D-06  -0.73258D-04  -0.39214D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.11734D-04   0.11156D-02   0.10343D+00  -0.14015D-06  -0.35261D-02   0.40910D-04
Fuel Slosh Mass Locat.             600     0.77455D-05  -0.25494D-03  -0.26781D-01   0.11195D-05   0.45737D-02  -0.50676D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.17659D-03  -0.92924D-04   0.46193D-01  -0.10254D-02   0.43712D-03   0.43843D-03

MODE# 30/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    385.09       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11047D-01  -0.21324D-01   0.55668D-04   0.36031D-03   0.28800D-03   0.43856D-02
S1 Engine No:2 +Y-Z               1152    -0.49949D-02  -0.20933D-01  -0.22704D-03  -0.52739D-04   0.36881D-03   0.49204D-02
S1 Engine No:3 -Y-Z               1153     0.46536D-02  -0.20930D-01   0.93653D-04  -0.69577D-04  -0.35263D-03   0.49090D-02
S1 Engine No:4 -Y-Z               1154     0.10762D-01  -0.21235D-01  -0.11571D-03   0.26863D-03  -0.20971D-03   0.43627D-02
S1 Engine No:5 -Y+Z               1155     0.10930D-01  -0.20997D-01  -0.14680D-03  -0.44308D-03   0.35806D-03   0.44246D-02
S1 Engine No:6 -Y+Z               1156     0.47474D-02  -0.20707D-01  -0.27454D-03   0.26693D-03   0.30146D-03   0.50425D-02
S1 Engine No:7 +Y+Z               1157    -0.51312D-02  -0.20721D-01   0.39218D-03   0.15346D-03  -0.39455D-03   0.49882D-02
S1 Engine No:8 +Y+Z               1158    -0.11146D-01  -0.21162D-01   0.10458D-03  -0.49544D-03  -0.36908D-03   0.43675D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05   0.43403D-08  -0.73187D-06  -0.54007D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05   0.43403D-08  -0.73187D-06  -0.54007D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05   0.43403D-08  -0.73187D-06  -0.54007D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.54940D-03  -0.62366D-01   0.79843D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.97973D-04   0.10435D-01  -0.54256D-05  -0.16325D-07   0.84805D-06   0.55982D-02
Fuel Slosh Mass Locat.             600     0.18657D-03   0.21205D-01  -0.55536D-05   0.30774D-06  -0.26040D-06   0.96764D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.26121D-02  -0.14420D-01   0.18524D-03  -0.24002D-03   0.13362D-03   0.27706D-02

MODE# 31/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    387.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.44295D-02   0.13012D-03   0.19339D-01   0.10343D-03   0.45479D-02   0.29044D-03
S1 Engine No:2 +Y-Z               1152    -0.10124D-01  -0.20563D-04   0.19589D-01  -0.26692D-03   0.40766D-02   0.21918D-03
S1 Engine No:3 -Y-Z               1153    -0.10181D-01  -0.40836D-04   0.19511D-01   0.32814D-03   0.40798D-02  -0.26822D-03
S1 Engine No:4 -Y-Z               1154    -0.44923D-02  -0.17739D-03   0.19252D-01  -0.16612D-03   0.45900D-02  -0.29587D-03
S1 Engine No:5 -Y+Z               1155     0.45281D-02   0.31724D-03   0.19257D-01  -0.12761D-03   0.45768D-02   0.31667D-03
S1 Engine No:6 -Y+Z               1156     0.10132D-01   0.86944D-04   0.19616D-01   0.40058D-03   0.40482D-02   0.30388D-03
S1 Engine No:7 +Y+Z               1157     0.10078D-01   0.48355D-04   0.19699D-01  -0.33577D-03   0.40391D-02  -0.25691D-03
S1 Engine No:8 +Y+Z               1158     0.44856D-02  -0.20241D-03   0.19345D-01   0.55380D-04   0.45271D-02  -0.32197D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01  -0.80190D-06  -0.54805D-02   0.64608D-06
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01  -0.80190D-06  -0.54805D-02   0.64608D-06
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01  -0.80190D-06  -0.54805D-02   0.64608D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01
Stage-2 Tank Top, IMU Locat.     40015     0.38149D-06   0.76510D-05   0.61574D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.12099D-05   0.18069D-05  -0.13285D-01   0.47988D-06   0.55703D-02  -0.58072D-06
Fuel Slosh Mass Locat.             600     0.76400D-08   0.12270D-06  -0.20039D-01   0.17845D-06   0.86924D-03  -0.43739D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.36615D-04  -0.16884D-03   0.10598D-01  -0.16577D-03   0.70021D-03   0.12361D-03
--------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
