BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=100 sec
! This batch set creates dynamic models for Control Analysis at T=100 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
! --------------   Create Vehicle, TVC and Actuator Models  ------------
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=100.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=100.0 sec 
Actuator Model   : Stage-1 Linear Actuator
System Connection: System of 8 TVC Actuators
!
! --------------   Build the Flight Control System  ---------------------
Transf-Function  : Integrator
Transf-Function  : Alpha Estimator
Transf-Function  : Beta Estimator
Transf-Function  : Low Pass Filters
System Connection: Flight Control System 
!
!  -------------   Create Plant Models  ---------------------------------
System Connection: Plant Model at T=100 sec, Vehicle/ Actuators
System Connection: Closed-Loop System
System Connection: Open-Loop System
System Connection: Roll Loop Opened, Others Closed
System Connection: Pitch Loop Opened, Others Closed
System Connection: Yaw Loop Opened, Others Closed
!
!  -------------   Export to Matlab  -----------------------------------
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=100.0 sec            
To Matlab Format : Plant Model at T=100 sec, Vehicle/ Actuators
To Matlab Format : Mixing Logic for First Stage Model, at T=100.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
To Matlab Format : Flight Control System
To Matlab Format : Closed-Loop System
To Matlab Format : Open-Loop System
To Matlab Format : Roll Loop Opened, Others Closed
To Matlab Format : Pitch Loop Opened, Others Closed
To Matlab Format : Yaw Loop Opened, Others Closed
---------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=100.0 sec                 
! This is a Launch Vehicle Control Analysis Model at t=100 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 60% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.015 .
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   3040.01       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   22685.6      0.240995E+07  0.240899E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   59.2480       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   2.043         1952.95       359.490       65266.3    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   43.1968       67.8354       0.0          -0.7007    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.874         0.00         -0.01          0.06
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           51.743        0.00          0.0          -0.5497       -0.0731
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.00000      90.00000                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.4150       7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   1.32184      0.00413      -0.00018829     0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0          -0.07579       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.066178     -0.07579       0.00000       0.000         0.00000       0.00000      0.110066E-05
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.104445     -0.1193        0.00000       0.000         0.00000     -0.399258E-05   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.04          0.1193        0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25258.0       25258.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945       -1.0332     
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25258.0       25258.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332       -2.4945 
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25258.0       25258.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332       -2.4945
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25258.0       25258.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945       -1.0332 
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25258.0       25258.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945        1.0332
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25258.0       25258.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332        2.4945
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25258.0       25258.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332        2.4945
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25258.0       25258.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945        1.0332 

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.483     0.00       0.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.483     0.00       0.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.483     0.00       0.00    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.483     0.00000    0.00000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.483     0.00000    0.00000       

Number of Slosh Modes                                                                    :  2
LOX Mass (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :   565.1   3.11   3.11   0.015   0.015  55.29  0.0  0.0  
LH2 Mass (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :   194.8   3.11   3.11   0.015   0.015  26.25  0.0  0.0 

Number of Bending Modes                                                                  : 32
First Stage Flex Modes at 40% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=100.0 sec 
! Thrust Vector Control Matrix at t=100 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=100.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
System of 8 TVC Actuators
! Combination of 8 TVC Actuators in Parallel
Titles of Systems to be Combined
Title 1 Stage-1 Linear Actuator 
Title 2 Stage-1 Linear Actuator 
Title 3 Stage-1 Linear Actuator 
Title 4 Stage-1 Linear Actuator 
Title 5 Stage-1 Linear Actuator 
Title 6 Stage-1 Linear Actuator 
Title 7 Stage-1 Linear Actuator 
Title 8 Stage-1 Linear Actuator 
SYSTEM INPUTS TO SUBSYSTEM  1                                                           Engine # 1
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                Command Input
System Input  9 to Subsystem  1, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                           Engine # 2
System Input  2 to Subsystem  2, Input  1, Gain= 1.00000                                Command Input
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                           Engine # 3
System Input  3 to Subsystem  3, Input  1, Gain= 1.00000                                Command Input
System Input 11 to Subsystem  3, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                           Engine # 4
System Input  4 to Subsystem  4, Input  1, Gain= 1.00000                                Command Input
System Input 12 to Subsystem  4, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                           Engine # 5
System Input  5 to Subsystem  5, Input  1, Gain= 1.00000                                Command Input
System Input 13 to Subsystem  5, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  6                                                           Engine # 6
System Input  6 to Subsystem  6, Input  1, Gain= 1.00000                                Command Input
System Input 14 to Subsystem  6, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  7                                                           Engine # 7
System Input  7 to Subsystem  7, Input  1, Gain= 1.00000                                Command Input
System Input 15 to Subsystem  7, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  8                                                           Engine # 8
System Input  8 to Subsystem  8, Input  1, Gain= 1.00000                                Command Input
System Input 16 to Subsystem  8, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                        Engine # 1
System Output  1 from Subsystem  1, Output  1, Gain= 1.00000                            Deflection
System Output  9 from Subsystem  1, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                        Engine # 2
System Output  2 from Subsystem  2, Output  1, Gain= 1.00000                            Deflection
System Output 10 from Subsystem  2, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                        Engine # 3
System Output  3 from Subsystem  3, Output  1, Gain= 1.00000                            Deflection
System Output 11 from Subsystem  3, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                        Engine # 4
System Output  4 from Subsystem  4, Output  1, Gain= 1.00000                            Deflection
System Output 12 from Subsystem  4, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5                                                        Engine # 5
System Output  5 from Subsystem  5, Output  1, Gain= 1.00000                            Deflection
System Output 13 from Subsystem  5, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  6                                                        Engine # 6
System Output  6 from Subsystem  6, Output  1, Gain= 1.00000                            Deflection
System Output 14 from Subsystem  6, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  7                                                        Engine # 7
System Output  7 from Subsystem  7, Output  1, Gain= 1.00000                            Deflection
System Output 15 from Subsystem  7, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  8                                                        Engine # 8
System Output  8 from Subsystem  8, Output  1, Gain= 1.00000                            Deflection
System Output 16 from Subsystem  8, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
Definitions of Inputs  =  16
Engine # 1 delta command (rad)   
Engine # 2 delta command (rad)                                                              
Engine # 3 delta command (rad)                                                              
Engine # 4 delta command (rad)                                                              
Engine # 5 delta command (rad)                                                              
Engine # 6 delta command (rad)                                                              
Engine # 7 delta command (rad)                                                              
Engine # 8 delta command (rad)                                                              
Engine # 1 Load-Torque (ft-lb)    
Engine # 2 Load-Torque (ft-lb)    
Engine # 3 Load-Torque (ft-lb)    
Engine # 4 Load-Torque (ft-lb)    
Engine # 5 Load-Torque (ft-lb)    
Engine # 6 Load-Torque (ft-lb)    
Engine # 7 Load-Torque (ft-lb)    
Engine # 8 Load-Torque (ft-lb)    
 
Definitions of Outputs =  16
Engine # 1 deflection (rad)   
Engine # 2 deflection (rad)   
Engine # 3 deflection (rad)   
Engine # 4 deflection (rad)   
Engine # 5 deflection (rad)   
Engine # 6 deflection (rad)   
Engine # 7 deflection (rad)   
Engine # 8 deflection (rad)   
Engine # 1 accelerat. (rad/sec^2)   
Engine # 2 accelerat. (rad/sec^2)   
Engine # 3 accelerat. (rad/sec^2)   
Engine # 4 accelerat. (rad/sec^2)   
Engine # 5 accelerat. (rad/sec^2)   
Engine # 6 accelerat. (rad/sec^2)   
Engine # 7 accelerat. (rad/sec^2)   
Engine # 8 accelerat. (rad/sec^2)   
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Plant Model at T=100 sec, Vehicle/ Actuators
! Combines the Vehicle with the 8 Pitch and 8 Yaw Actuators
!
Titles of Systems to be Combined
Title 1 Launch Vehicle First Stage Analysis Model, T=100.0 sec                                                    
Title 2 System of 8 TVC Actuators              
Title 3 System of 8 TVC Actuators           
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   To Pitch Actuators (1-8)
System Input  1 to Subsystem  2, Input  1, Gain= 1.00000            
System Input  2 to Subsystem  2, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  2, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  2, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  2, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  2, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  2, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  2, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   To Yaw Actuators (1-8)
System Input  9 to Subsystem  3, Input  1, Gain= 1.00000            
System Input 10 to Subsystem  3, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  3, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  3, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  3, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  3, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  3, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  3, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  1                                                                  
System Input 17 to Subsystem  1, Input 33, Gain= 1.0                                            Wind-Gust
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                         Pitch Actuat to Vehicle 
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                    delta_y1  Pitch Engine Deflects  
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                    delta_y2
Subsystem  2, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                    delta_y3
Subsystem  2, Output  4 to Subsystem  1, Input  4, Gain= 1.0                                    delta_y4
Subsystem  2, Output  5 to Subsystem  1, Input  5, Gain= 1.0                                    delta_y5
Subsystem  2, Output  6 to Subsystem  1, Input  6, Gain= 1.0                                    delta_y6
Subsystem  2, Output  7 to Subsystem  1, Input  7, Gain= 1.0                                    delta_y7
Subsystem  2, Output  8 to Subsystem  1, Input  8, Gain= 1.0                                    delta_y8
Subsystem  2, Output  9 to Subsystem  1, Input  9, Gain= 1.0                                    dy1_dd    Engine Accels
Subsystem  2, Output 10 to Subsystem  1, Input 10, Gain= 1.0                                    dy2_dd
Subsystem  2, Output 11 to Subsystem  1, Input 11, Gain= 1.0                                    dy3_dd
Subsystem  2, Output 12 to Subsystem  1, Input 12, Gain= 1.0                                    dy4_dd
Subsystem  2, Output 13 to Subsystem  1, Input 13, Gain= 1.0                                    dy5_dd
Subsystem  2, Output 14 to Subsystem  1, Input 14, Gain= 1.0                                    dy6_dd
Subsystem  2, Output 15 to Subsystem  1, Input 15, Gain= 1.0                                    dy7_dd
Subsystem  2, Output 16 to Subsystem  1, Input 16, Gain= 1.0                                    dy8_dd
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                                                         Yaw Actuat to Vehicle 
Subsystem  3, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                    delta_z1  Yaw Engine Deflects
Subsystem  3, Output  2 to Subsystem  1, Input 18, Gain= 1.0                                    delta_z2
Subsystem  3, Output  3 to Subsystem  1, Input 19, Gain= 1.0                                    delta_z3
Subsystem  3, Output  4 to Subsystem  1, Input 20, Gain= 1.0                                    delta_z4
Subsystem  3, Output  5 to Subsystem  1, Input 21, Gain= 1.0                                    delta_z5
Subsystem  3, Output  6 to Subsystem  1, Input 22, Gain= 1.0                                    delta_z6
Subsystem  3, Output  7 to Subsystem  1, Input 23, Gain= 1.0                                    delta_z7
Subsystem  3, Output  8 to Subsystem  1, Input 24, Gain= 1.0                                    delta_z8
Subsystem  3, Output  9 to Subsystem  1, Input 25, Gain= 1.0                                    dz1_dd    Yaw Engine Accels
Subsystem  3, Output 10 to Subsystem  1, Input 26, Gain= 1.0                                    dz2_dd
Subsystem  3, Output 11 to Subsystem  1, Input 27, Gain= 1.0                                    dz3_dd
Subsystem  3, Output 12 to Subsystem  1, Input 28, Gain= 1.0                                    dz4_dd
Subsystem  3, Output 13 to Subsystem  1, Input 29, Gain= 1.0                                    dz5_dd
Subsystem  3, Output 14 to Subsystem  1, Input 30, Gain= 1.0                                    dz6_dd
Subsystem  3, Output 15 to Subsystem  1, Input 31, Gain= 1.0                                    dz7_dd
Subsystem  3, Output 16 to Subsystem  1, Input 32, Gain= 1.0                                    dz8_dd
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                         Load-Torq TLY to Pitch Actuat 
Subsystem  1, Output 17 to Subsystem  2, Input  9, Gain= 1.0                                    TL_y1
Subsystem  1, Output 18 to Subsystem  2, Input 10, Gain= 1.0                                    TL_y2
Subsystem  1, Output 19 to Subsystem  2, Input 11, Gain= 1.0                                    TL_y3
Subsystem  1, Output 20 to Subsystem  2, Input 12, Gain= 1.0                                    TL_y4
Subsystem  1, Output 21 to Subsystem  2, Input 13, Gain= 1.0                                    TL_y5
Subsystem  1, Output 22 to Subsystem  2, Input 14, Gain= 1.0                                    TL_y6
Subsystem  1, Output 23 to Subsystem  2, Input 15, Gain= 1.0                                    TL_y7
Subsystem  1, Output 24 to Subsystem  2, Input 16, Gain= 1.0                                    TL_y8
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Load-Torq TLZ to Yaw Actuators
Subsystem  1, Output 25 to Subsystem  3, Input  9, Gain= 1.0                                    TL_z1
Subsystem  1, Output 26 to Subsystem  3, Input 10, Gain= 1.0                                    TL_z2
Subsystem  1, Output 27 to Subsystem  3, Input 11, Gain= 1.0                                    TL_z3
Subsystem  1, Output 28 to Subsystem  3, Input 12, Gain= 1.0                                    TL_z4
Subsystem  1, Output 29 to Subsystem  3, Input 13, Gain= 1.0                                    TL_z5
Subsystem  1, Output 30 to Subsystem  3, Input 14, Gain= 1.0                                    TL_z6
Subsystem  1, Output 31 to Subsystem  3, Input 15, Gain= 1.0                                    TL_z7
Subsystem  1, Output 32 to Subsystem  3, Input 16, Gain= 1.0                                    TL_z8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                Vehicle Outputs
Via Matrix +I16                                                                     
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                Pitch Gimbal Deflects
System Output 17 from Subsystem  2, Output  1, Gain= 1.0                                        dy-1
System Output 18 from Subsystem  2, Output  2, Gain= 1.0                                        dy-2
System Output 19 from Subsystem  2, Output  3, Gain= 1.0                                        dy-3
System Output 20 from Subsystem  2, Output  4, Gain= 1.0                                        dy-4
System Output 21 from Subsystem  2, Output  5, Gain= 1.0                                        dy-5
System Output 22 from Subsystem  2, Output  6, Gain= 1.0                                        dy-6
System Output 23 from Subsystem  2, Output  7, Gain= 1.0                                        dy-7
System Output 24 from Subsystem  2, Output  8, Gain= 1.0                                        dy-8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                Yaw Gimbal Deflects
System Output 25 from Subsystem  3, Output  1, Gain= 1.0                                        dz-1
System Output 26 from Subsystem  3, Output  2, Gain= 1.0                                        dz-2
System Output 27 from Subsystem  3, Output  3, Gain= 1.0                                        dz-3
System Output 28 from Subsystem  3, Output  4, Gain= 1.0                                        dz-4
System Output 29 from Subsystem  3, Output  5, Gain= 1.0                                        dz-5
System Output 30 from Subsystem  3, Output  6, Gain= 1.0                                        dz-6
System Output 31 from Subsystem  3, Output  7, Gain= 1.0                                        dz-7
System Output 32 from Subsystem  3, Output  8, Gain= 1.0                                        dz-8
..............................................................................
Definitions of Inputs  =  17
Engine Pitch Deflect Comd delta y_1 (rad)   
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)   
Wind-Gust Velocity (ft/sec)
 
Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Alpha Estimator
Continuous
TF. Block #  1 Nz-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Alfa Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at 5.13 (rad/sec)                      Order of Numer, Denom=  2  2
Numer 1.0         0.08        26.214
Denom 1.0         1.9         26.214
......................................................
Block #, from Input #, Gain
 2       1    -25258.0                                           Eng #1 Dy
 2       2    -25258.0                                           Eng #2 Dy
 2       3    -25258.0                                           Eng #3 Dy
 2       4    -25258.0                                           Eng #4 Dy
 2       5    -25258.0                                           Eng #5 Dy
 2       6    -25258.0                                           Eng #6 Dy
 2       7    -25258.0                                           Eng #7 Dy
 2       8    -25258.0                                           Eng #8 Dy
 1       9     20.0                                              Pitch Rate q
 2      10    -3040.0                                            Zdd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    -3040.0                                            Vehi Mass
 2       3    -1210.0                                            Qbar.Sref.Cza
 3       2     0.0004                                            Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (rad)
............................
Definitions of Inputs  =  10
Engine # 1 DY Deflection in (rad)
Engine # 2 DY Deflection in (rad)
Engine # 3 DY Deflection in (rad)
Engine # 4 DY Deflection in (rad)
Engine # 5 DY Deflection in (rad)
Engine # 6 DY Deflection in (rad)
Engine # 7 DY Deflection in (rad)
Engine # 8 DY Deflection in (rad)
Vehicle Pitch Rate      (rad/sec)                                            
Normal  Accelerat. Nz (ft/sec^2)                                                
 
Definitions of Outputs =   1
Alpha Estimate in (rad)
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Beta Estimator
Continuous
TF. Block #  1 Ny-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Beta Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at 5.13 (rad/sec)                      Order of Numer, Denom=  2  2
Numer 1.0         0.08        26.214
Denom 1.0         1.9         26.214
......................................................
Block #, from Input #, Gain
 2       1     25258.0                                           Eng #1 Dz
 2       2     25258.0                                           Eng #2 Dz
 2       3     25258.0                                           Eng #3 Dz
 2       4     25258.0                                           Eng #4 Dz
 2       5     25258.0                                           Eng #5 Dz
 2       6     25258.0                                           Eng #6 Dz
 2       7     25258.0                                           Eng #7 Dz
 2       8     25258.0                                           Eng #8 Dz
 1       9     20.0                                              Yaw Rate r
 2      10    -3040.0                                            Ydd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    +3040.0                                            Vehi Mass
 2       3    -1210.0                                            Qbar.Sref.Cyb
 3       2     0.0004                                            Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (rad)
............................
Definitions of Inputs  =  10
Engine # 1 DZ Deflection in (rad)
Engine # 2 DZ Deflection in (rad)
Engine # 3 DZ Deflection in (rad)
Engine # 4 DZ Deflection in (rad)
Engine # 5 DZ Deflection in (rad)
Engine # 6 DZ Deflection in (rad)
Engine # 7 DZ Deflection in (rad)
Engine # 8 DZ Deflection in (rad)
Vehicle Yaw Rate      (rad/sec)                                            
Lateral Accelerat. Ny (ft/sec^2)                                                
 
Definitions of Outputs =   1
Beta Estimate in (rad)
---------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Integrator
Continuous
TF. Block #  1    1/s                                            Order of Numer, Denom=  0  1
Numer 0.0         1.0      
Denom 1.0         0.0      
......................................................
Block #, from Input #, Gain
  1  1    1.0                             
...........................
Outpt #, from Block #, Gain
  1  1    1.0
...........................
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Low Pass Filters
Continuous
TF. Block #  1 Roll Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         900.0
Denom 1.0         39.0        900.0
TF. Block #  2 Ptch Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         576.0
Denom 1.0         31.2        576.0
TF. Block #  3 Yaw Low-Pass                                      Order of Numer, Denom=  0  2
Numer 0.0         0.0         576.0
Denom 1.0         31.2        576.0
TF. Block #  4 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  5 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  6 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
......................................................
Block #, from Input #, Gain
 1       1        1.0                                            
 2       2        1.0                                            
 3       3        1.0                                            
...........................
Block #, from Block #, Gain
 4       1        1.0                                 
 5       2        1.0                                 
 6       3        1.0                                 
............................
Outpt #, from Block #, Gain
 1       4        1.0                                            DP_TVC
 2       5        1.0                                            DQ_TVC
 3       6        1.0                                            DR_TVC
............................
Definitions of Inputs  =   3
Roll   Filter Input
Pitch  Filter Input
Yaw    Filter Input
 
Definitions of Outputs =   3
Roll   Filter Output DP_tvc
Pitch  Filter Output DQ_tvc
Yaw    Filter Output DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Flight Control System
! Combine the Filters, Gains and Alpha/Beta Estimators
!
Titles of Systems to be Combined
Title 1 Alpha Estimator
Title 2 Beta Estimator
Title 3 Low Pass Filters
Title 4 Integrator
Title 5 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                                   to Alfa Estimator
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                        Pitch Gimbal Deflects DY (1-8)
System Input  2 to Subsystem  1, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  1, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  1, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  1, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  1, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  1, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  1, Input  8, Gain= 1.00000            
System Input 21 to Subsystem  1, Input  9, Gain= 1.00000                                        Pitch Rate Q
System Input 23 to Subsystem  1, Input 10, Gain= 1.00000                                        NZ Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   to Beta Estimator
System Input  9 to Subsystem  2, Input  1, Gain= 1.00000                                        Yaw Gimbal Deflects DZ (1-8)
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  2, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  2, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  2, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  2, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  2, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  2, Input  8, Gain= 1.00000            
System Input 22 to Subsystem  2, Input  9, Gain= 1.00000                                        Yaw Rate R
System Input 24 to Subsystem  2, Input 10, Gain= 1.00000                                        NY Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   to Low-Pass Filters 
System Input 17 to Subsystem  3, Input  1, Gain= 2.5                                            KL_phi
System Input 18 to Subsystem  3, Input  2, Gain= 6.5                                            KM_theta
System Input 19 to Subsystem  3, Input  3, Gain= 6.5                                            KN_psi
System Input 20 to Subsystem  3, Input  1, Gain= 2.2                                            KL_p
System Input 21 to Subsystem  3, Input  2, Gain= 3.3                                            KM_q
System Input 22 to Subsystem  3, Input  3, Gain= 3.3                                            KN_r
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Alfa Estim to Filters
Subsystem  1, Output  1 to Subsystem  3, Input  2, Gain= 3.1                                    KM_alfa
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                                         Beta Estim to Filters
Subsystem  2, Output  1 to Subsystem  3, Input  3, Gain= -3.1                                   KN_beta
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  4                                                         Alfa Estim to Integrator
Subsystem  1, Output  1 to Subsystem  4, Input  1, Gain= 1.0                                    alfin
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  5                                                         Beta Estim to Integrator
Subsystem  2, Output  1 to Subsystem  5, Input  1, Gain= 1.0                                    betin
..............................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  3                                                         alfin to Low-Pass
Subsystem  4, Output  1 to Subsystem  3, Input  2, Gain= -0.095                                 KM_alfint
..............................................................................
SUBSYSTEM NO  5 GOES TO SUBSYSTEM NO  3                                                         alfin to Low-Pass
Subsystem  5, Output  1 to Subsystem  3, Input  3, Gain=  0.095                                 KN_betint
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                from Low-Pass Filters 
System Output  1 from Subsystem  3, Output  1, Gain= -1.0                                       DP_tvc
System Output  2 from Subsystem  3, Output  2, Gain= -1.0                                       DQ_tvc
System Output  3 from Subsystem  3, Output  3, Gain= -1.0                                       DR_tvc
..............................................................................
Definitions of Inputs  =  24
Engine Pitch Deflect Comd delta y_1 (rad)  
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)  
Roll  Attitude Error (rad)                  
Pitch Attitude Error (rad)
Yaw   Attitude Error (rad)
Roll  Rate (rad/sec)                        
Pitch Rate (rad/sec)
Yaw   Rate (rad/sec)
Normal  Acceleration NZ (ft/sec^2)         
Lateral Acceleration NY (ft/sec^2)         
 
Definitions of Outputs =   3
Roll  FCS Demand DP_tvc
Pitch FCS Demand DQ_tvc
Yaw   FCS Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Closed-Loop System
! Combines the Plant Model with the Flight Control System in
! Closed-Loop form
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=100 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
System Input  1 to Subsystem  1, Input 17, Gain= -1.0                                                      Roll Command
System Input  2 to Subsystem  1, Input 18, Gain= -1.0                                                      Ptch Command
System Input  3 to Subsystem  1, Input 19, Gain= -1.0                                                      Yaw  Command
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehi
System Input  4 to Subsystem  2, Input 17, Gain=  1.0                                                      Wind Gust
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    FCS
Via Matrix +TVC                                                                     
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                                    FCS to Vehi
Via Matrix +TVC                                                                                            DY(8), DZ(8)                                                                     
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                           Vehicle Outputs
Via Matrix +I32                                                                     
..............................................................................
Definitions of Inputs  =   4
Roll  Attitude Command (rad)  
Pitch Attitude Command (rad)  
Yaw   Attitude Command (rad)  
Wind-Gust Velocity (feet/sec)

Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Open-Loop System
! Combines the Plant Model with the Flight Control System in
! Open-Loop config
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=100 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehicle
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           Vehicle Outputs
Via Matrix +I03                                                                     
..............................................................................
Definitions of Inputs  =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc

Definitions of Outputs =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Roll Loop Opened, Others Closed
! Roll Loop Opened for Roll Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                                       Roll Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  1, Gain= -1.0                                                  DP_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw Closed
..............................................................................
Definitions of Inputs  =   1
Roll Control Demand DP_tvc 

Definitions of Outputs =   1
Roll Control Demand DP_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Pitch Loop Opened, Others Closed
! Pitch Loop Opened for Pitch Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  2, Gain= 1.0                                                       Pitch Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  2, Gain= -1.0                                                  DQ_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw  Closed
..............................................................................
Definitions of Inputs  =   1
Pitch Control Demand DQ_tvc 

Definitions of Outputs =   1
Pitch Control Demand DQ_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Yaw Loop Opened, Others Closed
! Roll Loop Opened for Yaw Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  3, Gain= 1.0                                                       Yaw Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  3, Gain= -1.0                                                  DR_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll  Closed
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
..............................................................................
Definitions of Inputs  =   1
Yaw Control Demand DR_tvc 

Definitions of Outputs =   1
Yaw Control Demand DR_tvc 
--------------------------------------------------------------------------------------------------------------------------------
                            CONVERT TO MATLAB DATA
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=100.0 sec 
Matrix TVC
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=100.0 sec 
System
flex_vehicle.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Flight Control System
System
fcs.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model at T=100 sec, Vehicle/ Actuators
System
plant.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Closed-Loop System
System
closed_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Open-Loop System
System
open_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Roll Loop Opened, Others Closed
System
roll_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Loop Opened, Others Closed
System
pitch_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Yaw Loop Opened, Others Closed
System
yaw_open.m
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 40% Full
First Stage Flex Modes at 40% Full Tanks
! Flex Modes, First Stage 40% Full Tanks from files: Stg1_40%.Mod, Stg1_40%.Nod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    28.309       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.19556D-01  -0.15672D+00   0.22074D-02   0.47356D-05   0.10731D-03   0.81205D-02
S1 Engine No:2 +Y-Z               1152    -0.83268D-02  -0.15672D+00   0.22049D-02  -0.57344D-06   0.10629D-03   0.81469D-02
S1 Engine No:3 -Y-Z               1153     0.77909D-02  -0.15672D+00   0.22091D-02  -0.35425D-06   0.12252D-03   0.81470D-02
S1 Engine No:4 -Y-Z               1154     0.19341D-01  -0.15672D+00   0.22066D-02   0.44041D-05   0.12264D-03   0.81206D-02
S1 Engine No:5 -Y+Z               1155     0.19569D-01  -0.15672D+00   0.22065D-02  -0.48544D-05   0.10750D-03   0.81208D-02
S1 Engine No:6 -Y+Z               1156     0.83393D-02  -0.15672D+00   0.22048D-02   0.11997D-05   0.10598D-03   0.81470D-02
S1 Engine No:7 +Y+Z               1157    -0.77787D-02  -0.15672D+00   0.22099D-02   0.71171D-06   0.12280D-03   0.81470D-02
S1 Engine No:8 +Y+Z               1158    -0.19329D-01  -0.15672D+00   0.22075D-02  -0.49903D-05   0.12220D-03   0.81208D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.52668D-05  -0.28066D-01   0.39446D-03   0.42344D-07  -0.78931D-04  -0.56064D-02
Stage-2 Tank Top, IMU Locat.     40015     0.52668D-05  -0.28066D-01   0.39446D-03   0.42344D-07  -0.78931D-04  -0.56064D-02
Stage-2 Tank Top, IMU Locat.     40015     0.52668D-05  -0.28066D-01   0.39446D-03   0.42344D-07  -0.78931D-04  -0.56064D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.52668D-05  -0.28066D-01   0.39446D-03
Stage-2 Tank Top, IMU Locat.     40015     0.52668D-05  -0.28066D-01   0.39446D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.58030D-05   0.96576D-01  -0.13624D-02   0.38678D-07   0.22834D-04   0.16238D-02
Fuel Slosh Mass Locat.             600     0.61536D-05  -0.61921D-01   0.87079D-03   0.34459D-07   0.11003D-03   0.78060D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.75405D-04  -0.15847D+00   0.22323D-02  -0.48490D-04   0.13390D-03   0.94813D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    28.323       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.77988D-02   0.22135D-02   0.15696D+00   0.32242D-06   0.81614D-02  -0.12287D-03
S1 Engine No:2 +Y-Z               1152    -0.19369D-01   0.22112D-02   0.15696D+00  -0.43283D-05   0.81354D-02  -0.12272D-03
S1 Engine No:3 -Y-Z               1153    -0.19597D-01   0.22112D-02   0.15696D+00   0.42907D-05   0.81352D-02  -0.10714D-03
S1 Engine No:4 -Y-Z               1154    -0.83474D-02   0.22095D-02   0.15696D+00  -0.78108D-06   0.81612D-02  -0.10610D-03
S1 Engine No:5 -Y+Z               1155     0.77988D-02   0.22141D-02   0.15696D+00  -0.79650D-06   0.81616D-02  -0.12295D-03
S1 Engine No:6 -Y+Z               1156     0.19369D-01   0.22120D-02   0.15697D+00   0.46559D-05   0.81354D-02  -0.12241D-03
S1 Engine No:7 +Y+Z               1157     0.19596D-01   0.22119D-02   0.15697D+00  -0.46940D-05   0.81350D-02  -0.10724D-03
S1 Engine No:8 +Y+Z               1158     0.83472D-02   0.22096D-02   0.15696D+00   0.52180D-06   0.81612D-02  -0.10612D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.67101D-07   0.39538D-03   0.28004D-01  -0.14540D-06  -0.56080D-02   0.79043D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.67101D-07   0.39538D-03   0.28004D-01  -0.14540D-06  -0.56080D-02   0.79043D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.67101D-07   0.39538D-03   0.28004D-01  -0.14540D-06  -0.56080D-02   0.79043D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.67101D-07   0.39538D-03   0.28004D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.67101D-07   0.39538D-03   0.28004D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.75207D-07  -0.13611D-02  -0.96765D-01  -0.12575D-06   0.16250D-02  -0.22932D-04
Fuel Slosh Mass Locat.             600    -0.80762D-07   0.87477D-03   0.61994D-01  -0.10553D-06   0.78199D-02  -0.11009D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.11504D-05   0.22357D-02   0.15870D+00  -0.29099D-04   0.94938D-02  -0.13358D-03

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.922       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.37098D-02  -0.20282D-01  -0.18991D-05   0.15888D-05  -0.20300D-05   0.14531D-02
S1 Engine No:2 +Y-Z               1152    -0.16679D-02  -0.20281D-01  -0.27375D-05  -0.17311D-06  -0.20982D-05   0.14611D-02
S1 Engine No:3 -Y-Z               1153     0.12235D-02  -0.20281D-01  -0.13661D-05  -0.14233D-06   0.23448D-05   0.14609D-02
S1 Engine No:4 -Y-Z               1154     0.32653D-02  -0.20282D-01  -0.21931D-05   0.14788D-05   0.21923D-05   0.14527D-02
S1 Engine No:5 -Y+Z               1155     0.32654D-02  -0.20282D-01  -0.21787D-05  -0.16446D-05  -0.21424D-05   0.14528D-02
S1 Engine No:6 -Y+Z               1156     0.12232D-02  -0.20281D-01  -0.27818D-05   0.39007D-06  -0.26209D-05   0.14609D-02
S1 Engine No:7 +Y+Z               1157    -0.16682D-02  -0.20281D-01  -0.11192D-05   0.25770D-06   0.20347D-05   0.14610D-02
S1 Engine No:8 +Y+Z               1158    -0.37101D-02  -0.20282D-01  -0.19074D-05  -0.16960D-05   0.18529D-05   0.14531D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.17205D-03   0.40070D-02  -0.89451D-07   0.15926D-07   0.64456D-07   0.99678D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.17205D-03   0.40070D-02  -0.89451D-07   0.15926D-07   0.64456D-07   0.99678D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.17205D-03   0.40070D-02  -0.89451D-07   0.15926D-07   0.64456D-07   0.99678D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.17205D-03   0.40070D-02  -0.89451D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.17205D-03   0.40070D-02  -0.89451D-07

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.20364D-03   0.15066D-01   0.57946D-06   0.12036D-07  -0.38376D-07  -0.40392D-03
Fuel Slosh Mass Locat.             600    -0.21953D-03  -0.31448D-02  -0.13116D-05   0.79991D-08  -0.66784D-07   0.13465D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.19621D-03  -0.20955D-01  -0.10259D-05  -0.18998D-04   0.56201D-06   0.19704D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    52.597       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.17272D-02   0.36637D-05   0.22475D-01   0.22250D-07   0.17454D-02  -0.31942D-05
S1 Engine No:2 +Y-Z               1152    -0.41667D-02   0.23735D-05   0.22477D-01  -0.22601D-05   0.17342D-02  -0.30212D-05
S1 Engine No:3 -Y-Z               1153    -0.41669D-02   0.24733D-05   0.22478D-01   0.19186D-05   0.17342D-02   0.28271D-05
S1 Engine No:4 -Y-Z               1154    -0.17276D-02   0.18031D-05   0.22476D-01  -0.51420D-06   0.17454D-02   0.30852D-05
S1 Engine No:5 -Y+Z               1155     0.17273D-02   0.43221D-05   0.22476D-01  -0.58968D-06   0.17454D-02  -0.32386D-05
S1 Engine No:6 -Y+Z               1156     0.41667D-02   0.35544D-05   0.22478D-01   0.21229D-05   0.17342D-02  -0.28486D-05
S1 Engine No:7 +Y+Z               1157     0.41667D-02   0.36002D-05   0.22478D-01  -0.24451D-05   0.17341D-02   0.27737D-05
S1 Engine No:8 +Y+Z               1158     0.17276D-02   0.21927D-05   0.22475D-01   0.54922D-07   0.17454D-02   0.30754D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.19306D-08   0.89867D-08  -0.30205D-02  -0.15402D-06   0.20989D-02   0.99712D-07
Stage-2 Tank Top, IMU Locat.     40015     0.19306D-08   0.89867D-08  -0.30205D-02  -0.15402D-06   0.20989D-02   0.99712D-07
Stage-2 Tank Top, IMU Locat.     40015     0.19306D-08   0.89867D-08  -0.30205D-02  -0.15402D-06   0.20989D-02   0.99712D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.19306D-08   0.89867D-08  -0.30205D-02
Stage-2 Tank Top, IMU Locat.     40015     0.19306D-08   0.89867D-08  -0.30205D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.19814D-08  -0.88100D-06  -0.14632D-01  -0.19358D-06  -0.83380D-03  -0.62293D-07
Fuel Slosh Mass Locat.             600     0.18837D-08   0.20611D-05   0.19392D-02  -0.20909D-06   0.15799D-02  -0.94264D-07

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.24133D-07   0.91535D-06   0.23485D-01  -0.18091D-04   0.25067D-02   0.12151D-05

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.845       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.94349D-02   0.44246D-01  -0.32521D-04  -0.75085D-05   0.39626D-05  -0.39451D-02
S1 Engine No:2 +Y-Z               1152     0.38809D-02   0.44239D-01  -0.28533D-04   0.88530D-06   0.47612D-05  -0.39797D-02
S1 Engine No:3 -Y-Z               1153    -0.39989D-02   0.44239D-01  -0.34975D-04   0.69301D-06  -0.11734D-04  -0.39797D-02
S1 Engine No:4 -Y-Z               1154    -0.95634D-02   0.44246D-01  -0.31068D-04  -0.69271D-05  -0.11868D-04  -0.39451D-02
S1 Engine No:5 -Y+Z               1155    -0.95719D-02   0.44244D-01  -0.31386D-04   0.78662D-05   0.34981D-05  -0.39457D-02
S1 Engine No:6 -Y+Z               1156    -0.40170D-02   0.44237D-01  -0.28484D-04  -0.18641D-05   0.50600D-05  -0.39802D-02
S1 Engine No:7 +Y+Z               1157     0.38634D-02   0.44238D-01  -0.36216D-04  -0.12036D-05  -0.12498D-04  -0.39797D-02
S1 Engine No:8 +Y+Z               1158     0.94279D-02   0.44245D-01  -0.32331D-04   0.81428D-05  -0.11183D-04  -0.39451D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.28830D-04   0.25063D-01  -0.25984D-04  -0.12368D-06  -0.10428D-04  -0.10146D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.28830D-04   0.25063D-01  -0.25984D-04  -0.12368D-06  -0.10428D-04  -0.10146D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.28830D-04   0.25063D-01  -0.25984D-04  -0.12368D-06  -0.10428D-04  -0.10146D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.28830D-04   0.25063D-01  -0.25984D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.28830D-04   0.25063D-01  -0.25984D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.52556D-04  -0.13477D-01   0.93576D-05  -0.61084D-07   0.39224D-05   0.36970D-02
Fuel Slosh Mass Locat.             600    -0.65436D-04  -0.28461D-02   0.11910D-04  -0.30055D-08  -0.30566D-05  -0.34344D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.23960D-03   0.48230D-01  -0.51962D-04   0.11759D-03  -0.17531D-04  -0.69506D-02

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    68.245       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.37888D-02   0.60901D-04   0.42635D-01   0.57950D-06   0.38375D-02  -0.12745D-04
S1 Engine No:2 +Y-Z               1152    -0.91565D-02   0.57488D-04   0.42641D-01  -0.66576D-05   0.38045D-02  -0.12361D-04
S1 Engine No:3 -Y-Z               1153    -0.91655D-02   0.57947D-04   0.42641D-01   0.66186D-05   0.38046D-02   0.34511D-05
S1 Engine No:4 -Y-Z               1154    -0.38099D-02   0.55085D-04   0.42635D-01  -0.11410D-05   0.38376D-02   0.42053D-05
S1 Engine No:5 -Y+Z               1155     0.37890D-02   0.62010D-04   0.42635D-01  -0.13699D-05   0.38378D-02  -0.12892D-04
S1 Engine No:6 -Y+Z               1156     0.91565D-02   0.58805D-04   0.42642D-01   0.72922D-05   0.38044D-02  -0.11788D-04
S1 Engine No:7 +Y+Z               1157     0.91649D-02   0.59085D-04   0.42642D-01  -0.72744D-05   0.38044D-02   0.32754D-05
S1 Engine No:8 +Y+Z               1158     0.38097D-02   0.55298D-04   0.42635D-01   0.70403D-06   0.38376D-02   0.41713D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.39893D-07   0.27005D-04   0.25711D-01  -0.90320D-07   0.99414D-02  -0.10526D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.39893D-07   0.27005D-04   0.25711D-01  -0.90320D-07   0.99414D-02  -0.10526D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.39893D-07   0.27005D-04   0.25711D-01  -0.90320D-07   0.99414D-02  -0.10526D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.39893D-07   0.27005D-04   0.25711D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.39893D-07   0.27005D-04   0.25711D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.60187D-07  -0.17627D-04  -0.12513D-01  -0.13667D-06  -0.36049D-02   0.36955D-05
Fuel Slosh Mass Locat.             600    -0.69301D-07   0.58607D-05  -0.27846D-02  -0.15245D-06   0.33097D-02  -0.39635D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.20632D-06   0.46738D-04   0.46335D-01  -0.67949D-04   0.66036D-02   0.29360D-05

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    107.11       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.10220D-05   0.10694D-01   0.25822D-01   0.10820D-01  -0.61448D-06   0.26424D-07
S1 Engine No:2 +Y-Z               1152     0.15837D-05   0.25822D-01   0.10694D-01   0.10820D-01  -0.87521D-06  -0.26690D-06
S1 Engine No:3 -Y-Z               1153     0.93892D-06   0.25822D-01  -0.10700D-01   0.10820D-01  -0.27770D-06  -0.26303D-06
S1 Engine No:4 -Y-Z               1154    -0.15186D-06   0.10694D-01  -0.25828D-01   0.10820D-01  -0.57349D-06  -0.42922D-08
S1 Engine No:5 -Y+Z               1155    -0.14226D-05  -0.10700D-01  -0.25828D-01   0.10820D-01  -0.58484D-06  -0.58589D-06
S1 Engine No:6 -Y+Z               1156    -0.17719D-05  -0.25829D-01  -0.10700D-01   0.10820D-01  -0.32227D-06  -0.27908D-06
S1 Engine No:7 +Y+Z               1157    -0.13474D-05  -0.25829D-01   0.10694D-01   0.10820D-01  -0.88727D-06  -0.28243D-06
S1 Engine No:8 +Y+Z               1158    -0.45023D-07  -0.10700D-01   0.25822D-01   0.10820D-01  -0.59188D-06  -0.55512D-06

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.15271D-06  -0.11033D-05   0.87468D-05  -0.50424D-02  -0.16882D-05  -0.29137D-06
Stage-2 Tank Top, IMU Locat.     40015     0.15271D-06  -0.11033D-05   0.87468D-05  -0.50424D-02  -0.16882D-05  -0.29137D-06
Stage-2 Tank Top, IMU Locat.     40015     0.15271D-06  -0.11033D-05   0.87468D-05  -0.50424D-02  -0.16882D-05  -0.29137D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.15271D-06  -0.11033D-05   0.87468D-05
Stage-2 Tank Top, IMU Locat.     40015     0.15271D-06  -0.11033D-05   0.87468D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.14230D-08   0.24355D-05  -0.30538D-05   0.54070D-02   0.75294D-06   0.23797D-06
Fuel Slosh Mass Locat.             600    -0.10632D-06  -0.54386D-05   0.36265D-05   0.10030D-01  -0.38935D-06  -0.24895D-07

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.20184D-05   0.17722D-04  -0.13372D-04   0.12542D-01  -0.98098D-05  -0.16673D-04

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    115.58       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.99127D-02  -0.27659D-01   0.72828D-03   0.26538D-05   0.13525D-03   0.42499D-02
S1 Engine No:2 +Y-Z               1152    -0.41243D-02  -0.27660D-01   0.73629D-03  -0.12881D-04   0.13296D-03   0.42893D-02
S1 Engine No:3 -Y-Z               1153     0.43652D-02  -0.27660D-01   0.76849D-03  -0.11791D-04   0.13202D-03   0.42910D-02
S1 Engine No:4 -Y-Z               1154     0.10533D-01  -0.27659D-01   0.77606D-03   0.12359D-05   0.13568D-03   0.42544D-02
S1 Engine No:5 -Y+Z               1155     0.10805D-01  -0.27633D-01   0.77805D-03  -0.25325D-04   0.13834D-03   0.42560D-02
S1 Engine No:6 -Y+Z               1156     0.50140D-02  -0.27605D-01   0.75794D-03  -0.67970D-05   0.13690D-03   0.42923D-02
S1 Engine No:7 +Y+Z               1157    -0.34769D-02  -0.27605D-01   0.74987D-03  -0.89298D-05   0.13823D-03   0.42889D-02
S1 Engine No:8 +Y+Z               1158    -0.96447D-02  -0.27636D-01   0.72676D-03  -0.25854D-04   0.13619D-03   0.42497D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.27738D-03   0.31190D-01  -0.94048D-03   0.99238D-05   0.42233D-03   0.13968D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.27738D-03   0.31190D-01  -0.94048D-03   0.99238D-05   0.42233D-03   0.13968D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.27738D-03   0.31190D-01  -0.94048D-03   0.99238D-05   0.42233D-03   0.13968D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.27738D-03   0.31190D-01  -0.94048D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.27738D-03   0.31190D-01  -0.94048D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.16334D-03  -0.25232D-01   0.81413D-03  -0.32196D-05  -0.17892D-03  -0.58219D-02
Fuel Slosh Mass Locat.             600     0.39416D-03   0.21726D-01  -0.78697D-03  -0.96665D-05   0.90566D-04   0.29988D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.18585D-02  -0.55578D-01   0.21038D-02  -0.99192D-03   0.10916D-02   0.24212D-01

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    115.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.38740D-02  -0.10008D-02  -0.29404D-01  -0.13834D-05  -0.42024D-02   0.12510D-03
S1 Engine No:2 +Y-Z               1152     0.99045D-02  -0.99429D-03  -0.29418D-01   0.12253D-04  -0.41582D-02   0.12716D-03
S1 Engine No:3 -Y-Z               1153     0.10150D-01  -0.99638D-03  -0.29416D-01  -0.13756D-04  -0.41580D-02   0.12024D-03
S1 Engine No:4 -Y-Z               1154     0.44633D-02  -0.99012D-03  -0.29402D-01   0.21596D-05  -0.42022D-02   0.11803D-03
S1 Engine No:5 -Y+Z               1155    -0.38564D-02  -0.10018D-02  -0.29402D-01   0.17184D-05  -0.42030D-02   0.12556D-03
S1 Engine No:6 -Y+Z               1156    -0.98864D-02  -0.99381D-03  -0.29417D-01  -0.15139D-04  -0.41580D-02   0.12589D-03
S1 Engine No:7 +Y+Z               1157    -0.10130D-01  -0.99548D-03  -0.29419D-01   0.13837D-04  -0.41573D-02   0.12059D-03
S1 Engine No:8 +Y+Z               1158    -0.44450D-02  -0.98911D-03  -0.29404D-01  -0.26424D-05  -0.42022D-02   0.11802D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.39706D-05   0.95977D-03   0.30915D-01  -0.35791D-06  -0.14142D-01   0.43787D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.39706D-05   0.95977D-03   0.30915D-01  -0.35791D-06  -0.14142D-01   0.43787D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.39706D-05   0.95977D-03   0.30915D-01  -0.35791D-06  -0.14142D-01   0.43787D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.39706D-05   0.95977D-03   0.30915D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.39706D-05   0.95977D-03   0.30915D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.44584D-05  -0.70860D-03  -0.24590D-01  -0.57090D-06   0.58146D-02  -0.17704D-03
Fuel Slosh Mass Locat.             600     0.83940D-05   0.46820D-03   0.19446D-01  -0.44680D-06  -0.30221D-02   0.93629D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.12716D-04  -0.10456D-02  -0.47868D-01   0.38807D-03  -0.17500D-01   0.17237D-03

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    120.40       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.28922D-06  -0.37610D-01  -0.90917D-01  -0.38086D-01   0.67913D-06  -0.24830D-06
S1 Engine No:2 +Y-Z               1152     0.33722D-06  -0.90861D-01  -0.37666D-01  -0.38086D-01   0.18990D-05   0.93953D-06
S1 Engine No:3 -Y-Z               1153     0.26500D-05  -0.90861D-01   0.37644D-01  -0.38086D-01  -0.86330D-06   0.90343D-06
S1 Engine No:4 -Y-Z               1154     0.42093D-05  -0.37610D-01   0.90895D-01  -0.38086D-01   0.40980D-06  -0.11563D-06
S1 Engine No:5 -Y+Z               1155     0.57089D-05   0.37700D-01   0.90895D-01  -0.38086D-01   0.55962D-06   0.25141D-05
S1 Engine No:6 -Y+Z               1156     0.47077D-05   0.90951D-01   0.37644D-01  -0.38086D-01  -0.54095D-06   0.10019D-05
S1 Engine No:7 +Y+Z               1157     0.33888D-05   0.90951D-01  -0.37666D-01  -0.38086D-01   0.18870D-05   0.97559D-06
S1 Engine No:8 +Y+Z               1158     0.87645D-06   0.37700D-01  -0.90917D-01  -0.38086D-01   0.50375D-06   0.23159D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.25446D-05  -0.12739D-04   0.27830D-05   0.32064D-01  -0.14867D-05  -0.77782D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.25446D-05  -0.12739D-04   0.27830D-05   0.32064D-01  -0.14867D-05  -0.77782D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.25446D-05  -0.12739D-04   0.27830D-05   0.32064D-01  -0.14867D-05  -0.77782D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.25446D-05  -0.12739D-04   0.27830D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.25446D-05  -0.12739D-04   0.27830D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.53685D-06  -0.79473D-05   0.37336D-05  -0.14686D-01   0.19153D-06   0.17244D-05
Fuel Slosh Mass Locat.             600     0.22863D-05   0.44206D-04  -0.13735D-04  -0.34578D-01  -0.19736D-06  -0.13094D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.18299D-04  -0.17608D-03   0.65688D-04  -0.46114D-01   0.63092D-04   0.16366D-03

MODE# 11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    130.92       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.20333D-01  -0.22943D-01   0.17221D-02  -0.37267D-04  -0.23585D-03  -0.32090D-02
S1 Engine No:2 +Y-Z               1152    -0.24484D-01  -0.23003D-01   0.17921D-02  -0.54738D-04  -0.13592D-03  -0.31609D-02
S1 Engine No:3 -Y-Z               1153    -0.30836D-01  -0.22994D-01   0.19166D-02  -0.56185D-04   0.90547D-05  -0.33367D-02
S1 Engine No:4 -Y-Z               1154    -0.35714D-01  -0.22929D-01   0.19789D-02  -0.34446D-04  -0.10049D-03  -0.36209D-02
S1 Engine No:5 -Y+Z               1155    -0.36225D-01  -0.22821D-01   0.19649D-02  -0.72563D-04  -0.42246D-03  -0.36319D-02
S1 Engine No:6 -Y+Z               1156    -0.32075D-01  -0.22740D-01   0.18816D-02  -0.46170D-04  -0.56009D-03  -0.33474D-02
S1 Engine No:7 +Y+Z               1157    -0.25724D-01  -0.22749D-01   0.17980D-02  -0.53177D-04  -0.41398D-03  -0.31499D-02
S1 Engine No:8 +Y+Z               1158    -0.20846D-01  -0.22839D-01   0.17185D-02  -0.68933D-04  -0.28825D-03  -0.31970D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.22800D-01   0.17187D-02  -0.13893D-03   0.42002D-04   0.21828D-03   0.26935D-02
Stage-2 Tank Top, IMU Locat.     40015     0.22800D-01   0.17187D-02  -0.13893D-03   0.42002D-04   0.21828D-03   0.26935D-02
Stage-2 Tank Top, IMU Locat.     40015     0.22800D-01   0.17187D-02  -0.13893D-03   0.42002D-04   0.21828D-03   0.26935D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.22800D-01   0.17187D-02  -0.13893D-03
Stage-2 Tank Top, IMU Locat.     40015     0.22800D-01   0.17187D-02  -0.13893D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10254D-01   0.16562D-01  -0.13341D-02  -0.30438D-04   0.38776D-04   0.48494D-03
Fuel Slosh Mass Locat.             600    -0.25216D-01  -0.48558D-01   0.39151D-02  -0.51149D-04  -0.28508D-04  -0.35550D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.41244D-01   0.19255D+00  -0.15518D-01   0.81767D-02  -0.12426D-01  -0.15424D+00

MODE# 12/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    142.50       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.40994D-02   0.96378D-03   0.11904D-01  -0.13866D-04  -0.55715D-02   0.37716D-03
S1 Engine No:2 +Y-Z               1152     0.12480D-01   0.93776D-03   0.11930D-01  -0.27254D-04  -0.57569D-02   0.36710D-03
S1 Engine No:3 -Y-Z               1153     0.13369D-01   0.92999D-03   0.11958D-01  -0.23500D-05  -0.57722D-02   0.54014D-03
S1 Engine No:4 -Y-Z               1154     0.62492D-02   0.94632D-03   0.11974D-01  -0.17857D-04  -0.55858D-02   0.56045D-03
S1 Engine No:5 -Y+Z               1155    -0.46959D-02   0.99321D-03   0.11975D-01  -0.15868D-04  -0.55739D-02   0.37192D-03
S1 Engine No:6 -Y+Z               1156    -0.13076D-01   0.10089D-02   0.11959D-01  -0.27800D-05  -0.57622D-02   0.36460D-03
S1 Engine No:7 +Y+Z               1157    -0.13966D-01   0.10009D-02   0.11928D-01  -0.27379D-04  -0.57774D-02   0.54253D-03
S1 Engine No:8 +Y+Z               1158    -0.68456D-02   0.97567D-03   0.11903D-01  -0.11861D-04  -0.55882D-02   0.56576D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.22304D-03   0.46625D-04   0.58253D-03   0.12338D-04   0.21976D-02  -0.17764D-03
Stage-2 Tank Top, IMU Locat.     40015     0.22304D-03   0.46625D-04   0.58253D-03   0.12338D-04   0.21976D-02  -0.17764D-03
Stage-2 Tank Top, IMU Locat.     40015     0.22304D-03   0.46625D-04   0.58253D-03   0.12338D-04   0.21976D-02  -0.17764D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.22304D-03   0.46625D-04   0.58253D-03
Stage-2 Tank Top, IMU Locat.     40015     0.22304D-03   0.46625D-04   0.58253D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.15755D-03  -0.19522D-02  -0.24007D-01  -0.12608D-04   0.13649D-02  -0.11114D-03
Fuel Slosh Mass Locat.             600    -0.28042D-03   0.49711D-02   0.61161D-01  -0.15696D-04  -0.14927D-02   0.12140D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.90372D-03  -0.20816D-01  -0.25573D+00   0.55390D-02  -0.19351D+00   0.15773D-01

MODE# 13/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    195.46       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.55162D-01   0.13766D+00  -0.10483D-01  -0.22560D-03  -0.17540D-02  -0.21977D-01
S1 Engine No:2 +Y-Z               1152     0.26405D-01   0.13742D+00  -0.10363D-01   0.38281D-04  -0.17197D-02  -0.22522D-01
S1 Engine No:3 -Y-Z               1153    -0.18195D-01   0.13742D+00  -0.10527D-01   0.27625D-05  -0.16178D-02  -0.22511D-01
S1 Engine No:4 -Y-Z               1154    -0.51693D-01   0.13766D+00  -0.10381D-01  -0.19806D-03  -0.16901D-02  -0.21962D-01
S1 Engine No:5 -Y+Z               1155    -0.55129D-01   0.13759D+00  -0.10404D-01   0.22805D-03  -0.17688D-02  -0.21991D-01
S1 Engine No:6 -Y+Z               1156    -0.26335D-01   0.13741D+00  -0.10345D-01  -0.94460D-04  -0.16978D-02  -0.22538D-01
S1 Engine No:7 +Y+Z               1157     0.18295D-01   0.13741D+00  -0.10595D-01  -0.35602D-04  -0.16313D-02  -0.22518D-01
S1 Engine No:8 +Y+Z               1158     0.51790D-01   0.13765D+00  -0.10464D-01   0.23236D-03  -0.16576D-02  -0.21971D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.71609D-04  -0.26798D-01   0.20121D-02  -0.52564D-05   0.35218D-03   0.46853D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.71609D-04  -0.26798D-01   0.20121D-02  -0.52564D-05   0.35218D-03   0.46853D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.71609D-04  -0.26798D-01   0.20121D-02  -0.52564D-05   0.35218D-03   0.46853D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.71609D-04  -0.26798D-01   0.20121D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.71609D-04  -0.26798D-01   0.20121D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.38351D-03   0.11278D+00  -0.85591D-02   0.13139D-04   0.92332D-03   0.12182D-01
Fuel Slosh Mass Locat.             600    -0.90022D-04  -0.11592D+00   0.88246D-02  -0.73565D-06  -0.10109D-02  -0.13303D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.49153D-02   0.71016D-01  -0.55323D-02  -0.39656D-02   0.14240D-02   0.20071D-01

MODE# 14/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    196.44       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.17779D-01   0.10444D-01   0.13702D+00   0.17611D-04   0.21905D-01  -0.15863D-02
S1 Engine No:2 +Y-Z               1152    -0.50386D-01   0.10335D-01   0.13722D+00  -0.18038D-03   0.21359D-01  -0.16420D-02
S1 Engine No:3 -Y-Z               1153    -0.53671D-01   0.10362D-01   0.13718D+00   0.20636D-03   0.21366D-01  -0.16698D-02
S1 Engine No:4 -Y-Z               1154    -0.25628D-01   0.10277D-01   0.13698D+00  -0.48680D-04   0.21913D-01  -0.16282D-02
