S1 Engine No:2 +Y-Z               1152    -0.37103D-01   0.52562D-02   0.10542D+00  -0.22928D-03   0.15391D-01  -0.81394D-03
S1 Engine No:3 -Y-Z               1153    -0.38706D-01   0.52765D-02   0.10551D+00   0.12538D-03   0.15394D-01  -0.79847D-03
S1 Engine No:4 -Y-Z               1154    -0.17807D-01   0.52816D-02   0.10541D+00  -0.10529D-03   0.15931D-01  -0.77063D-03
S1 Engine No:5 -Y+Z               1155     0.13803D-01   0.55829D-02   0.10541D+00  -0.90948D-04   0.15936D-01  -0.78089D-03
S1 Engine No:6 -Y+Z               1156     0.36905D-01   0.55551D-02   0.10553D+00   0.14310D-03   0.15384D-01  -0.79612D-03
S1 Engine No:7 +Y+Z               1157     0.38488D-01   0.55695D-02   0.10542D+00  -0.25367D-03   0.15379D-01  -0.80168D-03
S1 Engine No:8 +Y+Z               1158     0.17605D-01   0.53927D-02   0.10515D+00  -0.17734D-04   0.15929D-01  -0.76897D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01   0.11448D-04  -0.49738D-02   0.25447D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01   0.11448D-04  -0.49738D-02   0.25447D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01   0.11448D-04  -0.49738D-02   0.25447D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.72383D-04   0.22939D-02   0.47055D-01  -0.38850D-04  -0.13622D-01   0.68531D-03
Fuel Slosh Mass Locat.             600    -0.95712D-04  -0.91577D-04  -0.38421D-02  -0.56622D-04   0.13554D-01  -0.68404D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.18073D-03   0.16051D-02   0.41788D-01   0.22675D-02  -0.24989D-01   0.16878D-02

MODE# 15/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    257.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.25877D-01   0.69907D-01  -0.83851D-03  -0.17416D-03  -0.19752D-03  -0.10471D-01
S1 Engine No:2 +Y-Z               1152     0.11014D-01   0.69746D-01  -0.77930D-03   0.93919D-04  -0.19502D-03  -0.11055D-01
S1 Engine No:3 -Y-Z               1153    -0.10934D-01   0.69747D-01  -0.10853D-02   0.82055D-04  -0.86784D-04  -0.11056D-01
S1 Engine No:4 -Y-Z               1154    -0.26242D-01   0.69899D-01  -0.10274D-02  -0.14755D-03  -0.13976D-03  -0.10481D-01
S1 Engine No:5 -Y+Z               1155    -0.26613D-01   0.69721D-01  -0.10374D-02   0.29702D-03  -0.22422D-03  -0.10510D-01
S1 Engine No:6 -Y+Z               1156    -0.11711D-01   0.69445D-01  -0.87672D-03  -0.36472D-04  -0.19390D-03  -0.11085D-01
S1 Engine No:7 +Y+Z               1157     0.10274D-01   0.69449D-01  -0.10442D-02  -0.11828D-06  -0.12000D-03  -0.11057D-01
S1 Engine No:8 +Y+Z               1158     0.25577D-01   0.69767D-01  -0.83418D-03   0.30698D-03  -0.11182D-03  -0.10467D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03  -0.91014D-05  -0.13655D-04  -0.91117D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03  -0.91014D-05  -0.13655D-04  -0.91117D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03  -0.91014D-05  -0.13655D-04  -0.91117D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.39782D-03   0.13042D+00  -0.19625D-02   0.42964D-04   0.27811D-04   0.21389D-02
Fuel Slosh Mass Locat.             600    -0.33691D-03  -0.66160D-02   0.16968D-03   0.51712D-04  -0.12064D-03  -0.82895D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.22559D-02   0.45418D-01  -0.12007D-02  -0.43914D-02  -0.38921D-03   0.22921D-02

MODE# 16/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    258.09       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.10514D-01   0.11942D-02   0.70526D-01  -0.79446D-05   0.10964D-01  -0.12767D-03
S1 Engine No:2 +Y-Z               1152    -0.25743D-01   0.10242D-02   0.70791D-01  -0.23970D-03   0.10386D-01  -0.15588D-03
S1 Engine No:3 -Y-Z               1153    -0.26084D-01   0.10390D-02   0.70852D-01   0.16788D-03   0.10389D-01  -0.18410D-03
S1 Engine No:4 -Y-Z               1154    -0.11304D-01   0.10016D-02   0.70712D-01  -0.98070D-04   0.10970D-01  -0.17917D-03
S1 Engine No:5 -Y+Z               1155     0.10494D-01   0.13185D-02   0.70712D-01  -0.95620D-04   0.10976D-01  -0.13160D-03
S1 Engine No:6 -Y+Z               1156     0.25709D-01   0.12570D-02   0.70878D-01   0.19242D-03   0.10380D-01  -0.13168D-03
S1 Engine No:7 +Y+Z               1157     0.26024D-01   0.12649D-02   0.70811D-01  -0.26567D-03   0.10376D-01  -0.18810D-03
S1 Engine No:8 +Y+Z               1158     0.11265D-01   0.10825D-02   0.70526D-01  -0.64356D-06   0.10966D-01  -0.18121D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01   0.77614D-05   0.87654D-03  -0.12966D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01   0.77614D-05   0.87654D-03  -0.12966D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01   0.77614D-05   0.87654D-03  -0.12966D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.16618D-04   0.19241D-02   0.13073D+00  -0.35380D-04  -0.19566D-02   0.33079D-04
Fuel Slosh Mass Locat.             600    -0.18065D-04  -0.72520D-05  -0.52174D-02  -0.42428D-04   0.82223D-02  -0.12499D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.83825D-04   0.29138D-04   0.37263D-01   0.35836D-02  -0.86971D-02   0.55522D-03

MODE# 17/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    281.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.85768D-04  -0.10242D-01  -0.28368D-01  -0.11494D-01   0.91660D-05   0.34948D-04
S1 Engine No:2 +Y-Z               1152     0.91213D-04  -0.26312D-01  -0.12300D-01  -0.11484D-01   0.31951D-04   0.12148D-04
S1 Engine No:3 -Y-Z               1153     0.96725D-04  -0.26312D-01   0.10420D-01  -0.11491D-01   0.10936D-04   0.21348D-05
S1 Engine No:4 -Y-Z               1154     0.11096D-03  -0.10238D-01   0.26494D-01  -0.11492D-01  -0.68780D-05   0.28392D-04
S1 Engine No:5 -Y+Z               1155     0.10848D-03   0.12481D-01   0.26494D-01  -0.11482D-01   0.11606D-04   0.46469D-04
S1 Engine No:6 -Y+Z               1156     0.10177D-03   0.28547D-01   0.10425D-01  -0.11494D-01   0.34576D-04   0.14464D-04
S1 Engine No:7 +Y+Z               1157     0.99383D-04   0.28548D-01  -0.12306D-01  -0.11486D-01   0.22681D-04  -0.96511D-06
S1 Engine No:8 +Y+Z               1158     0.82699D-04   0.12486D-01  -0.28368D-01  -0.11484D-01  -0.31730D-05   0.26104D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04   0.19912D-02  -0.21992D-06  -0.32531D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04   0.19912D-02  -0.21992D-06  -0.32531D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04   0.19912D-02  -0.21992D-06  -0.32531D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.85847D-04   0.30647D-03  -0.25758D-03  -0.10659D-01   0.52621D-06   0.92196D-06
Fuel Slosh Mass Locat.             600     0.91694D-04   0.99256D-03  -0.81637D-03  -0.11367D-01  -0.48326D-05  -0.34667D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.49319D-03  -0.59041D-02   0.43504D-02   0.11662D+01   0.24125D-02   0.36655D-02

MODE# 18/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.50       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.19418D-01  -0.44199D-01   0.15771D-02   0.29689D-03   0.54901D-03   0.77059D-02
S1 Engine No:2 +Y-Z               1152    -0.89818D-02  -0.43893D-01   0.13880D-02  -0.51404D-04   0.56854D-03   0.82600D-02
S1 Engine No:3 -Y-Z               1153     0.73434D-02  -0.43893D-01   0.16264D-02  -0.27449D-04   0.20312D-03   0.82337D-02
S1 Engine No:4 -Y-Z               1154     0.18868D-01  -0.44186D-01   0.14339D-02   0.25286D-03   0.28566D-03   0.76802D-02
S1 Engine No:5 -Y+Z               1155     0.19735D-01  -0.44093D-01   0.14340D-02  -0.30245D-03   0.58409D-03   0.77443D-02
S1 Engine No:6 -Y+Z               1156     0.92410D-02  -0.43870D-01   0.13482D-02   0.15655D-03   0.55103D-03   0.83056D-02
S1 Engine No:7 +Y+Z               1157    -0.71565D-02  -0.43875D-01   0.17582D-02   0.88409D-04   0.22398D-03   0.82489D-02
S1 Engine No:8 +Y+Z               1158    -0.18662D-01  -0.44172D-01   0.15849D-02  -0.31460D-03   0.23150D-03   0.76738D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04  -0.23396D-05  -0.59456D-06  -0.36424D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04  -0.23396D-05  -0.59456D-06  -0.36424D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04  -0.23396D-05  -0.59456D-06  -0.36424D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.35340D-03   0.50211D-02  -0.48013D-03   0.15089D-04  -0.39366D-04   0.92808D-02
Fuel Slosh Mass Locat.             600     0.13723D-03   0.74193D-02  -0.99640D-03   0.12474D-04   0.28643D-03   0.51522D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.23113D-02  -0.29949D-01   0.11421D-02  -0.16452D-02   0.25439D-03   0.19286D-02

MODE# 19/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.67       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.52406D-01  -0.66960D-01   0.18037D-01   0.49411D-03   0.53318D-02   0.21084D-01
S1 Engine No:2 +Y-Z               1152    -0.30567D-01  -0.66472D-01   0.17803D-01  -0.15880D-03   0.53184D-02   0.21066D-01
S1 Engine No:3 -Y-Z               1153     0.10409D-01  -0.66465D-01   0.18119D-01   0.56450D-04   0.36475D-02   0.20824D-01
S1 Engine No:4 -Y-Z               1154     0.44615D-01  -0.67020D-01   0.17704D-01   0.36067D-03   0.39181D-02   0.20834D-01
S1 Engine No:5 -Y+Z               1155     0.53813D-01  -0.66745D-01   0.17748D-01  -0.50800D-03   0.54198D-02   0.21192D-01
S1 Engine No:6 -Y+Z               1156     0.31857D-01  -0.66425D-01   0.17727D-01   0.38114D-03   0.53185D-02   0.21181D-01
S1 Engine No:7 +Y+Z               1157    -0.92688D-02  -0.66430D-01   0.18397D-01   0.57359D-04   0.37158D-02   0.20834D-01
S1 Engine No:8 +Y+Z               1158    -0.43427D-01  -0.66999D-01   0.18010D-01  -0.48152D-03   0.38287D-02   0.20783D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03  -0.47956D-05  -0.10629D-04   0.33070D-03
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03  -0.47956D-05  -0.10629D-04   0.33070D-03
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03  -0.47956D-05  -0.10629D-04   0.33070D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.48719D-03   0.29826D-01  -0.54718D-02   0.30913D-04  -0.29833D-03  -0.12546D-01
Fuel Slosh Mass Locat.             600     0.57954D-03   0.64273D-01  -0.10875D-01   0.25501D-04   0.32647D-02   0.15622D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.33864D-02  -0.39595D-01   0.96782D-02  -0.33803D-02   0.20075D-03   0.67987D-02

MODE# 20/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.70       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.77011D-02  -0.16803D-01  -0.76746D-01  -0.12925D-04  -0.19442D-01   0.44293D-02
S1 Engine No:2 +Y-Z               1152     0.40779D-01  -0.16459D-01  -0.77245D-01   0.37704D-03  -0.19062D-01   0.45358D-02
S1 Engine No:3 -Y-Z               1153     0.50713D-01  -0.16501D-01  -0.77064D-01  -0.48589D-03  -0.19463D-01   0.56056D-02
S1 Engine No:4 -Y-Z               1154     0.31155D-01  -0.16373D-01  -0.76669D-01   0.23030D-03  -0.19801D-01   0.56558D-02
S1 Engine No:5 -Y+Z               1155    -0.74105D-02  -0.16848D-01  -0.76659D-01   0.15943D-04  -0.19456D-01   0.44546D-02
S1 Engine No:6 -Y+Z               1156    -0.40462D-01  -0.16445D-01  -0.77237D-01  -0.48055D-03  -0.19042D-01   0.44879D-02
S1 Engine No:7 +Y+Z               1157    -0.50344D-01  -0.16470D-01  -0.77179D-01   0.49982D-03  -0.19410D-01   0.56134D-02
S1 Engine No:8 +Y+Z               1158    -0.30844D-01  -0.16317D-01  -0.76754D-01  -0.23945D-03  -0.19796D-01   0.56562D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02   0.24011D-05   0.48926D-04   0.70044D-04
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02   0.24011D-05   0.48926D-04   0.70044D-04
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02   0.24011D-05   0.48926D-04   0.70044D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.13376D-03   0.70693D-02   0.23295D-01  -0.15203D-04   0.11290D-02  -0.27442D-02
Fuel Slosh Mass Locat.             600     0.14921D-03   0.15090D-01   0.45895D-01  -0.12494D-04  -0.13901D-01   0.37502D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.92427D-03  -0.91239D-02  -0.38518D-01   0.17035D-02   0.13382D-02   0.10759D-02

MODE# 21/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    318.90       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11063D-01   0.28406D-03   0.25618D-01   0.46805D-04   0.11500D-01   0.47736D-03
S1 Engine No:2 +Y-Z               1152    -0.26601D-01   0.20584D-03   0.25783D-01  -0.13123D-03   0.11886D-01   0.41838D-03
S1 Engine No:3 -Y-Z               1153    -0.26726D-01   0.24622D-03   0.25740D-01   0.16610D-03   0.11892D-01  -0.54226D-03
S1 Engine No:4 -Y-Z               1154    -0.11335D-01   0.15533D-03   0.25554D-01  -0.52961D-04   0.11514D-01  -0.58320D-03
S1 Engine No:5 -Y+Z               1155     0.11079D-01   0.32540D-03   0.25554D-01  -0.49945D-04   0.11515D-01   0.47750D-03
S1 Engine No:6 -Y+Z               1156     0.26594D-01   0.20613D-03   0.25773D-01   0.19622D-03   0.11878D-01   0.44992D-03
S1 Engine No:7 +Y+Z               1157     0.26683D-01   0.23849D-03   0.25816D-01  -0.16124D-03   0.11877D-01  -0.54430D-03
S1 Engine No:8 +Y+Z               1158     0.11320D-01   0.13440D-03   0.25618D-01   0.43765D-04   0.11503D-01  -0.58837D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01  -0.79754D-06   0.39857D-03  -0.37765D-06
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01  -0.79754D-06   0.39857D-03  -0.37765D-06
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01  -0.79754D-06   0.39857D-03  -0.37765D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.64053D-05  -0.73563D-04  -0.17849D-01   0.84264D-05  -0.15960D-01   0.17824D-04
Fuel Slosh Mass Locat.             600    -0.56533D-05  -0.12577D-03  -0.46450D-01   0.73787D-05   0.92096D-02  -0.40189D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.43517D-04  -0.15518D-03   0.87845D-02  -0.93102D-03   0.13625D-02   0.19303D-03

MODE# 22/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    341.52       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.86066D-05  -0.10564D-01  -0.25587D-01  -0.10706D-01  -0.82428D-06  -0.47254D-05
S1 Engine No:2 +Y-Z               1152     0.59595D-05  -0.25541D-01  -0.10611D-01  -0.10706D-01   0.30095D-05  -0.14628D-05
S1 Engine No:3 -Y-Z               1153     0.42740D-05  -0.25541D-01   0.10571D-01  -0.10707D-01  -0.43883D-05  -0.16403D-05
S1 Engine No:4 -Y-Z               1154    -0.95927D-06  -0.10564D-01   0.25548D-01  -0.10706D-01  -0.12863D-05  -0.42974D-05
S1 Engine No:5 -Y+Z               1155    -0.17178D-05   0.10617D-01   0.25548D-01  -0.10706D-01  -0.88348D-06   0.28813D-05
S1 Engine No:6 -Y+Z               1156    -0.22763D-05   0.25594D-01   0.10571D-01  -0.10707D-01  -0.33928D-05  -0.16708D-05
S1 Engine No:7 +Y+Z               1157     0.30175D-05   0.25594D-01  -0.10611D-01  -0.10706D-01   0.32485D-05  -0.18403D-05
S1 Engine No:8 +Y+Z               1158     0.48784D-05   0.10618D-01  -0.25587D-01  -0.10706D-01  -0.11764D-05   0.21202D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06   0.40140D-02  -0.10083D-06  -0.78434D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06   0.40140D-02  -0.10083D-06  -0.78434D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06   0.40140D-02  -0.10083D-06  -0.78434D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.34689D-05  -0.72700D-05   0.60520D-05   0.23153D-02   0.15628D-06   0.65449D-06
Fuel Slosh Mass Locat.             600     0.24756D-05   0.12036D-04  -0.10458D-04  -0.93350D-02  -0.79399D-06  -0.13348D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.24941D-04  -0.15170D-03   0.10516D-03   0.19988D-01   0.53065D-04   0.89053D-04

MODE# 23/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    385.45       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.37289D-01  -0.35367D-01   0.19291D-03   0.78814D-03   0.13535D-02   0.16802D-01
S1 Engine No:2 +Y-Z               1152    -0.16320D-01  -0.34451D-01  -0.46307D-03  -0.11896D-03   0.15799D-02   0.16700D-01
S1 Engine No:3 -Y-Z               1153     0.15875D-01  -0.34444D-01   0.20451D-03  -0.15724D-03  -0.15463D-02   0.16684D-01
S1 Engine No:4 -Y-Z               1154     0.37004D-01  -0.35159D-01  -0.28076D-03   0.57370D-03  -0.11608D-02   0.16774D-01
S1 Engine No:5 -Y+Z               1155     0.37417D-01  -0.34616D-01  -0.30711D-03  -0.97036D-03   0.15294D-02   0.16920D-01
S1 Engine No:6 -Y+Z               1156     0.16144D-01  -0.33951D-01  -0.58522D-03   0.63092D-03   0.14497D-02   0.16998D-01
S1 Engine No:7 +Y+Z               1157    -0.16589D-01  -0.33984D-01   0.91431D-03   0.36482D-03  -0.16186D-02   0.16858D-01
S1 Engine No:8 +Y+Z               1158    -0.37500D-01  -0.35000D-01   0.26185D-03  -0.10916D-02  -0.15208D-02   0.16759D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04  -0.10839D-05  -0.24758D-05  -0.50692D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04  -0.10839D-05  -0.24758D-05  -0.50692D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04  -0.10839D-05  -0.24758D-05  -0.50692D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.93195D-03  -0.56183D-01   0.36713D-04   0.56236D-05  -0.38612D-05  -0.85740D-02
Fuel Slosh Mass Locat.             600    -0.29381D-04   0.64561D-01  -0.51166D-04   0.25369D-05   0.57498D-05   0.11245D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.48923D-02  -0.17456D-01   0.37384D-03  -0.50195D-03   0.26696D-03   0.79482D-02

MODE# 24/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    387.43       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.16111D-01  -0.30189D-03  -0.34855D-01  -0.27095D-03  -0.16802D-01  -0.14693D-02
S1 Engine No:2 +Y-Z               1152     0.37456D-01   0.69413D-04  -0.35488D-01   0.62360D-03  -0.16964D-01  -0.12427D-02
S1 Engine No:3 -Y-Z               1153     0.37606D-01   0.76465D-04  -0.35284D-01  -0.78582D-03  -0.16972D-01   0.13732D-02
S1 Engine No:4 -Y-Z               1154     0.16283D-01   0.42063D-03  -0.34620D-01   0.42394D-03  -0.16910D-01   0.14898D-02
S1 Engine No:5 -Y+Z               1155    -0.16356D-01  -0.77114D-03  -0.34633D-01   0.32449D-03  -0.16874D-01  -0.15361D-02
S1 Engine No:6 -Y+Z               1156    -0.37470D-01  -0.18744D-03  -0.35551D-01  -0.96925D-03  -0.16891D-01  -0.14573D-02
S1 Engine No:7 +Y+Z               1157    -0.37337D-01  -0.13383D-03  -0.35768D-01   0.79919D-03  -0.16868D-01   0.13446D-02
S1 Engine No:8 +Y+Z               1158    -0.16261D-01   0.49210D-03  -0.34871D-01  -0.14869D-03  -0.16750D-01   0.15562D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01   0.16789D-05   0.51186D-02  -0.25808D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01   0.16789D-05   0.51186D-02  -0.25808D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01   0.16789D-05   0.51186D-02  -0.25808D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10542D-04  -0.19048D-04  -0.56634D-01  -0.44063D-05   0.82526D-02  -0.44597D-05
Fuel Slosh Mass Locat.             600     0.42673D-05   0.12661D-04   0.64401D-01  -0.11106D-05  -0.11242D-01   0.53204D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.72853D-04   0.36528D-03  -0.11866D-01   0.36482D-03  -0.39662D-02  -0.26580D-03

MODE# 25/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    427.91       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.94065D-01   0.85144D-01   0.27368D-02  -0.15305D-01  -0.14185D-01  -0.36198D-01
S1 Engine No:2 +Y-Z               1152     0.51317D-01   0.73796D-01   0.98886D-02   0.81127D-02  -0.14246D-01  -0.54638D-01
S1 Engine No:3 -Y-Z               1153    -0.52048D-01   0.74109D-01  -0.12660D-01   0.54464D-02   0.15820D-01  -0.52916D-01
S1 Engine No:4 -Y-Z               1154    -0.92090D-01   0.87818D-01  -0.26777D-02  -0.15108D-01   0.12560D-01  -0.34145D-01
S1 Engine No:5 -Y+Z               1155    -0.92419D-01   0.88585D-01   0.19558D-03   0.14024D-01  -0.13097D-01  -0.35850D-01
S1 Engine No:6 -Y+Z               1156    -0.50638D-01   0.76569D-01   0.87114D-02  -0.55238D-02  -0.14398D-01  -0.52811D-01
S1 Engine No:7 +Y+Z               1157     0.49344D-01   0.76708D-01  -0.90429D-02  -0.42199D-02   0.15072D-01  -0.51713D-01
S1 Engine No:8 +Y+Z               1158     0.90666D-01   0.88820D-01   0.21616D-04   0.12574D-01   0.10861D-01  -0.34501D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03   0.28214D-05  -0.11404D-04  -0.23303D-02
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03   0.28214D-05  -0.11404D-04  -0.23303D-02
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03   0.28214D-05  -0.11404D-04  -0.23303D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.30007D-02   0.14085D+00  -0.67336D-03  -0.12913D-04   0.11125D-04   0.23538D-02
Fuel Slosh Mass Locat.             600    -0.51250D-03  -0.16306D+00   0.78645D-03  -0.66830D-06  -0.12289D-03  -0.25940D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.18199D-01   0.37763D-01  -0.99220D-03   0.79337D-03  -0.67102D-03  -0.23131D-01

MODE# 26/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    428.10       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.49930D-01  -0.10465D-01  -0.76609D-01  -0.53196D-02  -0.52088D-01  -0.13694D-01
S1 Engine No:2 +Y-Z               1152     0.92722D-01  -0.22409D-02  -0.88249D-01   0.13454D-01  -0.36103D-01  -0.11859D-01
S1 Engine No:3 -Y-Z               1153     0.92433D-01   0.27850D-03  -0.89216D-01  -0.12640D-01  -0.36083D-01   0.11646D-01
S1 Engine No:4 -Y-Z               1154     0.50176D-01   0.86423D-02  -0.77731D-01   0.44864D-02  -0.51473D-01   0.14070D-01
S1 Engine No:5 -Y+Z               1155    -0.48777D-01  -0.84834D-02  -0.77639D-01   0.51893D-02  -0.51824D-01  -0.13243D-01
S1 Engine No:6 -Y+Z               1156    -0.92524D-01  -0.10915D-02  -0.88203D-01  -0.12229D-01  -0.36371D-01  -0.11092D-01
S1 Engine No:7 +Y+Z               1157    -0.93545D-01   0.13210D-02  -0.87278D-01   0.13021D-01  -0.36398D-01   0.12070D-01
S1 Engine No:8 +Y+Z               1158    -0.50392D-01   0.86132D-02  -0.76531D-01  -0.59501D-02  -0.52439D-01   0.13783D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01   0.17946D-05  -0.23746D-02   0.10912D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01   0.17946D-05  -0.23746D-02   0.10912D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01   0.17946D-05  -0.23746D-02   0.10912D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.61300D-04  -0.66063D-03  -0.14060D+00  -0.86507D-05   0.23683D-02  -0.11245D-04
Fuel Slosh Mass Locat.             600     0.91848D-05   0.75531D-03   0.16225D+00  -0.57930D-06  -0.25951D-01   0.12306D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.35424D-03   0.71866D-03  -0.22391D-01   0.55042D-03  -0.12143D-01  -0.51437D-03

MODE# 27/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    463.99       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.39562D-02  -0.20086D-01  -0.46074D-03   0.43067D-02   0.23509D-02  -0.71135D-02
S1 Engine No:2 +Y-Z               1152    -0.33728D-02  -0.16573D-01  -0.29846D-02  -0.17648D-02   0.31765D-02   0.11350D-02
S1 Engine No:3 -Y-Z               1153    -0.88509D-03  -0.16565D-01   0.31303D-02  -0.17609D-02  -0.27770D-02   0.95191D-03
S1 Engine No:4 -Y-Z               1154    -0.82335D-02  -0.20083D-01   0.58910D-03   0.43217D-02  -0.21982D-02  -0.75042D-02
S1 Engine No:5 -Y+Z               1155    -0.82975D-02  -0.20138D-01  -0.40010D-03  -0.42739D-02   0.21298D-02  -0.75260D-02
S1 Engine No:6 -Y+Z               1156    -0.94981D-03  -0.16610D-01  -0.29731D-02   0.16798D-02   0.27599D-02   0.88366D-03
S1 Engine No:7 +Y+Z               1157    -0.33510D-02  -0.16610D-01   0.30145D-02   0.17509D-02  -0.31523D-02   0.11242D-02
S1 Engine No:8 +Y+Z               1158     0.39471D-02  -0.20096D-01   0.51128D-03  -0.42881D-02  -0.23654D-02  -0.70708D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05  -0.17210D-05  -0.85244D-05  -0.29124D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05  -0.17210D-05  -0.85244D-05  -0.29124D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05  -0.17210D-05  -0.85244D-05  -0.29124D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.69369D-02   0.22441D-01  -0.67308D-04   0.59514D-05   0.16165D-04   0.53899D-02
Fuel Slosh Mass Locat.             600    -0.82029D-03  -0.41280D-01   0.12481D-03  -0.25459D-05  -0.11984D-04  -0.39619D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.22179D-01  -0.23163D-01   0.14410D-03  -0.13526D-03   0.66114D-04   0.55414D-02

MODE# 28/ 38, Frequency (rad/sec), Damping (zeta), Generalized Mass=    464.01       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13621D-02   0.32281D-02   0.17131D-01   0.17755D-02   0.11561D-02   0.31247D-02
S1 Engine No:2 +Y-Z               1152     0.61396D-02   0.56826D-03   0.20799D-01  -0.44543D-02  -0.74575D-02   0.23510D-02
S1 Engine No:3 -Y-Z               1153     0.61320D-02  -0.44667D-03   0.20789D-01   0.44524D-02  -0.74231D-02  -0.23581D-02
S1 Engine No:4 -Y-Z               1154    -0.13049D-02  -0.30718D-02   0.17153D-01  -0.17990D-02   0.11646D-02  -0.30641D-02
S1 Engine No:5 -Y+Z               1155     0.14151D-02   0.31765D-02   0.17154D-01  -0.17884D-02   0.11624D-02   0.31129D-02
S1 Engine No:6 -Y+Z               1156    -0.60547D-02   0.54704D-03   0.20790D-01   0.44321D-02  -0.74407D-02   0.23434D-02
S1 Engine No:7 +Y+Z               1157    -0.60206D-02  -0.46671D-03   0.20741D-01  -0.44675D-02  -0.74096D-02  -0.23764D-02
S1 Engine No:8 +Y+Z               1158     0.13905D-02  -0.30623D-02   0.17123D-01   0.18450D-02   0.12013D-02  -0.30613D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02  -0.20812D-06  -0.28530D-02   0.86874D-05
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02  -0.20812D-06  -0.28530D-02   0.86874D-05
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02  -0.20812D-06  -0.28530D-02   0.86874D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.13110D-03  -0.67090D-04  -0.22468D-01   0.11179D-05   0.53812D-02  -0.16124D-04
Fuel Slosh Mass Locat.             600     0.16448D-04   0.12406D-03   0.41612D-01  -0.24356D-06  -0.39563D-02   0.11744D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.40530D-03  -0.14590D-04   0.15693D-01  -0.61704D-04   0.29540D-03   0.41311D-04

MODE# 29/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    469.98       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.24015D-01   0.40295D-02  -0.76000D-03   0.67454D-02   0.37564D-02  -0.17554D-01
S1 Engine No:2 +Y-Z               1152     0.33410D-02   0.94906D-02  -0.47745D-02  -0.27767D-02   0.49453D-02  -0.47788D-02
S1 Engine No:3 -Y-Z               1153    -0.56929D-02   0.94910D-02   0.47868D-02  -0.27336D-02  -0.46793D-02  -0.49284D-02
S1 Engine No:4 -Y-Z               1154    -0.26282D-01   0.40646D-02   0.77927D-03   0.66622D-02  -0.34968D-02  -0.17816D-01
S1 Engine No:5 -Y+Z               1155    -0.26113D-01   0.41746D-02  -0.85793D-03  -0.67630D-02   0.36776D-02  -0.17770D-01
S1 Engine No:6 -Y+Z               1156    -0.54757D-02   0.95920D-02  -0.48130D-02   0.28895D-02   0.47489D-02  -0.47852D-02
S1 Engine No:7 +Y+Z               1157     0.33910D-02   0.95745D-02   0.49701D-02   0.27727D-02  -0.49768D-02  -0.47684D-02
S1 Engine No:8 +Y+Z               1158     0.24099D-01   0.40318D-02   0.88044D-03  -0.67766D-02  -0.36630D-02  -0.17663D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04   0.11275D-05  -0.23450D-04   0.66907D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04   0.11275D-05  -0.23450D-04   0.66907D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04   0.11275D-05  -0.23450D-04   0.66907D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.22539D-02   0.30321D-01   0.99559D-04  -0.36350D-05   0.34292D-05  -0.80371D-03
Fuel Slosh Mass Locat.             600    -0.55225D-03  -0.52032D-01  -0.17580D-03   0.19510D-05   0.22300D-04  -0.66433D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.29318D-02  -0.41963D-02  -0.13243D-03   0.55670D-04  -0.68479D-04  -0.29448D-02

MODE# 30/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.57       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.14520D-01   0.16899D-01   0.10702D-01   0.12562D-01   0.52750D-02  -0.10533D-01
S1 Engine No:2 +Y-Z               1152     0.87175D-03   0.29839D-01  -0.48949D-03   0.14988D-02   0.59664D-02   0.16595D-02
S1 Engine No:3 -Y-Z               1153     0.38164D-02   0.29787D-01   0.58420D-03   0.18302D-02  -0.65016D-02   0.16534D-02
S1 Engine No:4 -Y-Z               1154    -0.97665D-02   0.16939D-01  -0.10635D-01   0.12186D-01  -0.51992D-02  -0.99815D-02
S1 Engine No:5 -Y+Z               1155    -0.94348D-02   0.79315D-02  -0.12407D-01  -0.30296D-02   0.55208D-02  -0.99463D-02
S1 Engine No:6 -Y+Z               1156     0.41971D-02   0.75439D-02  -0.10263D-01   0.80426D-02   0.65956D-02   0.19655D-02
S1 Engine No:7 +Y+Z               1157     0.63256D-03   0.75885D-02   0.10471D-01   0.83029D-02  -0.60503D-02   0.19140D-02
S1 Engine No:8 +Y+Z               1158     0.14316D-01   0.78453D-02   0.12586D-01  -0.33720D-02  -0.54575D-02  -0.10570D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04   0.17227D-02  -0.31940D-05   0.73841D-03
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04   0.17227D-02  -0.31940D-05   0.73841D-03
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04   0.17227D-02  -0.31940D-05   0.73841D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.61055D-02   0.19508D-01   0.84140D-04  -0.49544D-02  -0.45258D-05   0.10392D-02
Fuel Slosh Mass Locat.             600     0.14772D-02  -0.15859D-01  -0.70821D-04   0.35551D-02   0.14179D-04  -0.33596D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.66430D-01   0.32924D-01  -0.14575D-04  -0.17130D-02  -0.20296D-04  -0.17123D-01

MODE# 31/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.60       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.14187D-02  -0.57144D-01  -0.13615D+00  -0.57847D-01   0.20054D-03  -0.19020D-02
S1 Engine No:2 +Y-Z               1152    -0.17824D-02  -0.13721D+00  -0.56169D-01  -0.57270D-01   0.20746D-02  -0.59009D-03
S1 Engine No:3 -Y-Z               1153    -0.14292D-02  -0.13695D+00   0.59841D-01  -0.59497D-01   0.79540D-03   0.96168D-03
S1 Engine No:4 -Y-Z               1154    -0.76846D-03  -0.55578D-01   0.14162D+00  -0.56921D-01  -0.77491D-03  -0.56089D-04
S1 Engine No:5 -Y+Z               1155    -0.12351D-02   0.57913D-01   0.14145D+00  -0.58358D-01   0.23052D-03  -0.17821D-02
S1 Engine No:6 -Y+Z               1156     0.19102D-02   0.14046D+00   0.58826D-01  -0.58902D-01   0.19985D-02  -0.57698D-03
S1 Engine No:7 +Y+Z               1157     0.15698D-02   0.14072D+00  -0.55157D-01  -0.56657D-01   0.90886D-03   0.97270D-03
S1 Engine No:8 +Y+Z               1158     0.85113D-03   0.59481D-01  -0.13598D+00  -0.59300D-01  -0.80144D-03   0.27517D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03  -0.21047D-01  -0.97391D-04   0.61472D-04
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03  -0.21047D-01  -0.97391D-04   0.61472D-04
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03  -0.21047D-01  -0.97391D-04   0.61472D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.16722D-03   0.16350D-02   0.25682D-02   0.60500D-01  -0.13465D-03   0.86219D-04
Fuel Slosh Mass Locat.             600     0.39422D-04  -0.12776D-02  -0.20124D-02  -0.43459D-01   0.45272D-03  -0.28807D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.17711D-02   0.12173D-02   0.18689D-02   0.24649D-01   0.44972D-03  -0.42144D-03

MODE# 32/ 49, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.61       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.18211D-02   0.98862D-03   0.39379D-01   0.35842D-02  -0.23888D-02  -0.71090D-02
S1 Engine No:2 +Y-Z               1152    -0.13284D-01   0.16424D-01   0.21936D-01   0.16288D-01   0.11371D-01  -0.61708D-02
S1 Engine No:3 -Y-Z               1153    -0.13193D-01   0.18517D-01   0.73345D-02  -0.15830D-02   0.11590D-01   0.62470D-02
S1 Engine No:4 -Y-Z               1154     0.23878D-02   0.13454D-01   0.42865D-02   0.11118D-01  -0.23579D-02   0.75022D-02
S1 Engine No:5 -Y+Z               1155    -0.20336D-02  -0.13939D-01   0.43098D-02   0.11322D-01  -0.25039D-02  -0.71874D-02
S1 Engine No:6 -Y+Z               1156     0.13146D-01  -0.19158D-01   0.74654D-02  -0.16978D-02   0.11382D-01  -0.63120D-02
S1 Engine No:7 +Y+Z               1157     0.13367D-01  -0.17065D-01   0.21688D-01   0.16178D-01   0.11605D-01   0.60931D-02
S1 Engine No:8 +Y+Z               1158    -0.22593D-02  -0.13493D-02   0.39340D-01   0.39188D-02  -0.21632D-02   0.74952D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02   0.26777D-02  -0.76211D-03  -0.11544D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02   0.26777D-02  -0.76211D-03  -0.11544D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02   0.26777D-02  -0.76211D-03  -0.11544D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.11916D-04  -0.30714D-03   0.20161D-01  -0.76963D-02  -0.10567D-02  -0.16225D-04
Fuel Slosh Mass Locat.             600    -0.26205D-05   0.24104D-03  -0.15703D-01   0.55295D-02   0.35646D-02   0.53965D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.14984D-04  -0.43855D-03   0.12458D-01  -0.32281D-02   0.25039D-02   0.21712D-03
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
