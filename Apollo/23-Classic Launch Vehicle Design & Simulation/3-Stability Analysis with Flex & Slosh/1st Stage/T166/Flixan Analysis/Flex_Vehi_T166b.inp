BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=166 sec
! This batch set creates dynamic models for Control Analysis at T=166 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
! --------------   Create Vehicle, TVC and Actuator Models  ------------
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=166.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=166.0 sec 
Actuator Model   : Stage-1 Linear Actuator
System Connection: System of 8 TVC Actuators
!
! --------------   Build the Flight Control System  ---------------------
Transf-Function  : Integrator
Transf-Function  : Alpha Estimator
Transf-Function  : Beta Estimator
Transf-Function  : Low Pass Filters
System Connection: Flight Control System 
!
!  -------------   Create Plant Models  ---------------------------------
System Connection: Plant Model at T=166 sec, Vehicle/ Actuators
System Connection: Closed-Loop System
System Connection: Open-Loop System
System Connection: Roll Loop Opened, Others Closed
System Connection: Pitch Loop Opened, Others Closed
System Connection: Yaw Loop Opened, Others Closed
!
!  -------------   Export to Matlab  -----------------------------------
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=166.0 sec            
To Matlab Format : Plant Model at T=166 sec, Vehicle/ Actuators
To Matlab Format : Mixing Logic for First Stage Model, at T=166.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
To Matlab Format : Flight Control System
To Matlab Format : Closed-Loop System
To Matlab Format : Open-Loop System
To Matlab Format : Roll Loop Opened, Others Closed
To Matlab Format : Pitch Loop Opened, Others Closed
To Matlab Format : Yaw Loop Opened, Others Closed
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=166.0 sec                                       
! This is a Launch Vehicle Control Analysis Model at t=166 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 100% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.012 .
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   1551.56       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   12200.7      0.129732E+07  0.129636E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   75.8911       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   7.48600       7362.39       6.06000       222333.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   132.594       147.154       0.0           0.0086
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.6930        0.0          -0.05         -0.03
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          28.711        0.00000       0.0          -0.2564        0.0366
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.00         90.00                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.4150       7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.736018      0.002       -0.981123E-04   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0          -0.074         0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.051742     -0.074         0.00000       0.0           0.00000       0.00000     -0.169325E-06
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.14821      -0.1524        0.00000       0.00000       0.00000     -0.161171E-04   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0           0.1524        0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25396.9       25396.9       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       2.49450      -1.03320    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25396.9       25396.9       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       1.03320      -2.49450    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25396.9       25396.9       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -1.03320      -2.49450    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25396.9       25396.9       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -2.49450      -1.03320    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25396.9       25396.9       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -2.49450       1.03320    
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25396.9       25396.9       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -1.03320       2.49450    
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25396.9       25396.9       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       1.03320       2.49450    
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25396.9       25396.9       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       2.49450       1.03320    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438    0.000      0.000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438    0.000      0.000    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438    0.000      0.000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000       

Number of Slosh Modes                                                                    :  2
LOX Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   105.47  3.11   3.11   0.005  0.005  43.61   0.0  0.0  
LH2 Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   36.377  3.11   3.11   0.005  0.005  15.21   0.0  0.0 

Number of Bending Modes                                                                  : 32
First Stage Flex Modes at 20% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=166.0 sec 
! Thrust Vector Control Matrix at t=166 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=166.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
System of 8 TVC Actuators
! Combination of 8 TVC Actuators in Parallel
Titles of Systems to be Combined
Title 1 Stage-1 Linear Actuator 
Title 2 Stage-1 Linear Actuator 
Title 3 Stage-1 Linear Actuator 
Title 4 Stage-1 Linear Actuator 
Title 5 Stage-1 Linear Actuator 
Title 6 Stage-1 Linear Actuator 
Title 7 Stage-1 Linear Actuator 
Title 8 Stage-1 Linear Actuator 
SYSTEM INPUTS TO SUBSYSTEM  1                                                           Engine # 1
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                Command Input
System Input  9 to Subsystem  1, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                           Engine # 2
System Input  2 to Subsystem  2, Input  1, Gain= 1.00000                                Command Input
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                           Engine # 3
System Input  3 to Subsystem  3, Input  1, Gain= 1.00000                                Command Input
System Input 11 to Subsystem  3, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                           Engine # 4
System Input  4 to Subsystem  4, Input  1, Gain= 1.00000                                Command Input
System Input 12 to Subsystem  4, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                           Engine # 5
System Input  5 to Subsystem  5, Input  1, Gain= 1.00000                                Command Input
System Input 13 to Subsystem  5, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  6                                                           Engine # 6
System Input  6 to Subsystem  6, Input  1, Gain= 1.00000                                Command Input
System Input 14 to Subsystem  6, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  7                                                           Engine # 7
System Input  7 to Subsystem  7, Input  1, Gain= 1.00000                                Command Input
System Input 15 to Subsystem  7, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  8                                                           Engine # 8
System Input  8 to Subsystem  8, Input  1, Gain= 1.00000                                Command Input
System Input 16 to Subsystem  8, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                        Engine # 1
System Output  1 from Subsystem  1, Output  1, Gain= 1.00000                            Deflection
System Output  9 from Subsystem  1, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                        Engine # 2
System Output  2 from Subsystem  2, Output  1, Gain= 1.00000                            Deflection
System Output 10 from Subsystem  2, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                        Engine # 3
System Output  3 from Subsystem  3, Output  1, Gain= 1.00000                            Deflection
System Output 11 from Subsystem  3, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                        Engine # 4
System Output  4 from Subsystem  4, Output  1, Gain= 1.00000                            Deflection
System Output 12 from Subsystem  4, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5                                                        Engine # 5
System Output  5 from Subsystem  5, Output  1, Gain= 1.00000                            Deflection
System Output 13 from Subsystem  5, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  6                                                        Engine # 6
System Output  6 from Subsystem  6, Output  1, Gain= 1.00000                            Deflection
System Output 14 from Subsystem  6, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  7                                                        Engine # 7
System Output  7 from Subsystem  7, Output  1, Gain= 1.00000                            Deflection
System Output 15 from Subsystem  7, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  8                                                        Engine # 8
System Output  8 from Subsystem  8, Output  1, Gain= 1.00000                            Deflection
System Output 16 from Subsystem  8, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
Definitions of Inputs  =  16
Engine # 1 delta command (rad)   
Engine # 2 delta command (rad)                                                              
Engine # 3 delta command (rad)                                                              
Engine # 4 delta command (rad)                                                              
Engine # 5 delta command (rad)                                                              
Engine # 6 delta command (rad)                                                              
Engine # 7 delta command (rad)                                                              
Engine # 8 delta command (rad)                                                              
Engine # 1 Load-Torque (ft-lb)    
Engine # 2 Load-Torque (ft-lb)    
Engine # 3 Load-Torque (ft-lb)    
Engine # 4 Load-Torque (ft-lb)    
Engine # 5 Load-Torque (ft-lb)    
Engine # 6 Load-Torque (ft-lb)    
Engine # 7 Load-Torque (ft-lb)    
Engine # 8 Load-Torque (ft-lb)    
 
Definitions of Outputs =  16
Engine # 1 deflection (rad)   
Engine # 2 deflection (rad)   
Engine # 3 deflection (rad)   
Engine # 4 deflection (rad)   
Engine # 5 deflection (rad)   
Engine # 6 deflection (rad)   
Engine # 7 deflection (rad)   
Engine # 8 deflection (rad)   
Engine # 1 accelerat. (rad/sec^2)   
Engine # 2 accelerat. (rad/sec^2)   
Engine # 3 accelerat. (rad/sec^2)   
Engine # 4 accelerat. (rad/sec^2)   
Engine # 5 accelerat. (rad/sec^2)   
Engine # 6 accelerat. (rad/sec^2)   
Engine # 7 accelerat. (rad/sec^2)   
Engine # 8 accelerat. (rad/sec^2)   
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Plant Model at T=166 sec, Vehicle/ Actuators
! Combines the Vehicle with the 8 Pitch and 8 Yaw Actuators
!
Titles of Systems to be Combined
Title 1 Launch Vehicle First Stage Analysis Model, T=166.0 sec                                                    
Title 2 System of 8 TVC Actuators              
Title 3 System of 8 TVC Actuators           
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   To Pitch Actuators (1-8)
System Input  1 to Subsystem  2, Input  1, Gain= 1.00000            
System Input  2 to Subsystem  2, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  2, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  2, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  2, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  2, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  2, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  2, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   To Yaw Actuators (1-8)
System Input  9 to Subsystem  3, Input  1, Gain= 1.00000            
System Input 10 to Subsystem  3, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  3, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  3, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  3, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  3, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  3, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  3, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  1                                                                  
System Input 17 to Subsystem  1, Input 33, Gain= 1.0                                            Wind-Gust
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                         Pitch Actuat to Vehicle 
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                    delta_y1  Pitch Engine Deflects  
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                    delta_y2
Subsystem  2, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                    delta_y3
Subsystem  2, Output  4 to Subsystem  1, Input  4, Gain= 1.0                                    delta_y4
Subsystem  2, Output  5 to Subsystem  1, Input  5, Gain= 1.0                                    delta_y5
Subsystem  2, Output  6 to Subsystem  1, Input  6, Gain= 1.0                                    delta_y6
Subsystem  2, Output  7 to Subsystem  1, Input  7, Gain= 1.0                                    delta_y7
Subsystem  2, Output  8 to Subsystem  1, Input  8, Gain= 1.0                                    delta_y8
Subsystem  2, Output  9 to Subsystem  1, Input  9, Gain= 1.0                                    dy1_dd    Engine Accels
Subsystem  2, Output 10 to Subsystem  1, Input 10, Gain= 1.0                                    dy2_dd
Subsystem  2, Output 11 to Subsystem  1, Input 11, Gain= 1.0                                    dy3_dd
Subsystem  2, Output 12 to Subsystem  1, Input 12, Gain= 1.0                                    dy4_dd
Subsystem  2, Output 13 to Subsystem  1, Input 13, Gain= 1.0                                    dy5_dd
Subsystem  2, Output 14 to Subsystem  1, Input 14, Gain= 1.0                                    dy6_dd
Subsystem  2, Output 15 to Subsystem  1, Input 15, Gain= 1.0                                    dy7_dd
Subsystem  2, Output 16 to Subsystem  1, Input 16, Gain= 1.0                                    dy8_dd
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                                                         Yaw Actuat to Vehicle 
Subsystem  3, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                    delta_z1  Yaw Engine Deflects
Subsystem  3, Output  2 to Subsystem  1, Input 18, Gain= 1.0                                    delta_z2
Subsystem  3, Output  3 to Subsystem  1, Input 19, Gain= 1.0                                    delta_z3
Subsystem  3, Output  4 to Subsystem  1, Input 20, Gain= 1.0                                    delta_z4
Subsystem  3, Output  5 to Subsystem  1, Input 21, Gain= 1.0                                    delta_z5
Subsystem  3, Output  6 to Subsystem  1, Input 22, Gain= 1.0                                    delta_z6
Subsystem  3, Output  7 to Subsystem  1, Input 23, Gain= 1.0                                    delta_z7
Subsystem  3, Output  8 to Subsystem  1, Input 24, Gain= 1.0                                    delta_z8
Subsystem  3, Output  9 to Subsystem  1, Input 25, Gain= 1.0                                    dz1_dd    Yaw Engine Accels
Subsystem  3, Output 10 to Subsystem  1, Input 26, Gain= 1.0                                    dz2_dd
Subsystem  3, Output 11 to Subsystem  1, Input 27, Gain= 1.0                                    dz3_dd
Subsystem  3, Output 12 to Subsystem  1, Input 28, Gain= 1.0                                    dz4_dd
Subsystem  3, Output 13 to Subsystem  1, Input 29, Gain= 1.0                                    dz5_dd
Subsystem  3, Output 14 to Subsystem  1, Input 30, Gain= 1.0                                    dz6_dd
Subsystem  3, Output 15 to Subsystem  1, Input 31, Gain= 1.0                                    dz7_dd
Subsystem  3, Output 16 to Subsystem  1, Input 32, Gain= 1.0                                    dz8_dd
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                         Load-Torq TLY to Pitch Actuat 
Subsystem  1, Output 17 to Subsystem  2, Input  9, Gain= 1.0                                    TL_y1
Subsystem  1, Output 18 to Subsystem  2, Input 10, Gain= 1.0                                    TL_y2
Subsystem  1, Output 19 to Subsystem  2, Input 11, Gain= 1.0                                    TL_y3
Subsystem  1, Output 20 to Subsystem  2, Input 12, Gain= 1.0                                    TL_y4
Subsystem  1, Output 21 to Subsystem  2, Input 13, Gain= 1.0                                    TL_y5
Subsystem  1, Output 22 to Subsystem  2, Input 14, Gain= 1.0                                    TL_y6
Subsystem  1, Output 23 to Subsystem  2, Input 15, Gain= 1.0                                    TL_y7
Subsystem  1, Output 24 to Subsystem  2, Input 16, Gain= 1.0                                    TL_y8
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Load-Torq TLZ to Yaw Actuators
Subsystem  1, Output 25 to Subsystem  3, Input  9, Gain= 1.0                                    TL_z1
Subsystem  1, Output 26 to Subsystem  3, Input 10, Gain= 1.0                                    TL_z2
Subsystem  1, Output 27 to Subsystem  3, Input 11, Gain= 1.0                                    TL_z3
Subsystem  1, Output 28 to Subsystem  3, Input 12, Gain= 1.0                                    TL_z4
Subsystem  1, Output 29 to Subsystem  3, Input 13, Gain= 1.0                                    TL_z5
Subsystem  1, Output 30 to Subsystem  3, Input 14, Gain= 1.0                                    TL_z6
Subsystem  1, Output 31 to Subsystem  3, Input 15, Gain= 1.0                                    TL_z7
Subsystem  1, Output 32 to Subsystem  3, Input 16, Gain= 1.0                                    TL_z8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                Vehicle Outputs
Via Matrix +I16                                                                     
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                Pitch Gimbal Deflects
System Output 17 from Subsystem  2, Output  1, Gain= 1.0                                        dy-1
System Output 18 from Subsystem  2, Output  2, Gain= 1.0                                        dy-2
System Output 19 from Subsystem  2, Output  3, Gain= 1.0                                        dy-3
System Output 20 from Subsystem  2, Output  4, Gain= 1.0                                        dy-4
System Output 21 from Subsystem  2, Output  5, Gain= 1.0                                        dy-5
System Output 22 from Subsystem  2, Output  6, Gain= 1.0                                        dy-6
System Output 23 from Subsystem  2, Output  7, Gain= 1.0                                        dy-7
System Output 24 from Subsystem  2, Output  8, Gain= 1.0                                        dy-8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                Yaw Gimbal Deflects
System Output 25 from Subsystem  3, Output  1, Gain= 1.0                                        dz-1
System Output 26 from Subsystem  3, Output  2, Gain= 1.0                                        dz-2
System Output 27 from Subsystem  3, Output  3, Gain= 1.0                                        dz-3
System Output 28 from Subsystem  3, Output  4, Gain= 1.0                                        dz-4
System Output 29 from Subsystem  3, Output  5, Gain= 1.0                                        dz-5
System Output 30 from Subsystem  3, Output  6, Gain= 1.0                                        dz-6
System Output 31 from Subsystem  3, Output  7, Gain= 1.0                                        dz-7
System Output 32 from Subsystem  3, Output  8, Gain= 1.0                                        dz-8
..............................................................................
Definitions of Inputs  =  17
Engine Pitch Deflect Comd delta y_1 (rad)   
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)   
Wind-Gust Velocity (ft/sec)
 
Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Alpha Estimator
Continuous
TF. Block #  1 Nz-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Alfa Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at (Dummy)                             Order of Numer, Denom=  2  2
Numer 1.0         1.0        13.838
Denom 1.0         1.0        13.838
......................................................
Block #, from Input #, Gain
 2       1    -25397.0                                           Eng #1 Dy
 2       2    -25397.0                                           Eng #2 Dy
 2       3    -25397.0                                           Eng #3 Dy
 2       4    -25397.0                                           Eng #4 Dy
 2       5    -25397.0                                           Eng #5 Dy
 2       6    -25397.0                                           Eng #6 Dy
 2       7    -25397.0                                           Eng #7 Dy
 2       8    -25397.0                                           Eng #8 Dy
 1       9     30.0                                              Pitch Rate q
 2      10    -1551.5                                            Zdd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    -1551.5                                            Vehi Mass
 2       3    -19.92                                             Qbar.Sref.Cza
 3       2     0.05                                              Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (deg2rad)
............................
Definitions of Inputs  =  10
Engine # 1 DY Deflection in (rad)
Engine # 2 DY Deflection in (rad)
Engine # 3 DY Deflection in (rad)
Engine # 4 DY Deflection in (rad)
Engine # 5 DY Deflection in (rad)
Engine # 6 DY Deflection in (rad)
Engine # 7 DY Deflection in (rad)
Engine # 8 DY Deflection in (rad)
Vehicle Pitch Rate      (rad/sec)                                            
Normal  Accelerat. Nz (ft/sec^2)                                                
 
Definitions of Outputs =   1
Alpha Estimate in (rad)
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Beta Estimator
Continuous
TF. Block #  1 Ny-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Beta Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at (Dummy)                             Order of Numer, Denom=  2  2
Numer 1.0         1.0        13.838
Denom 1.0         1.0        13.838
......................................................
Block #, from Input #, Gain
 2       1     25397.0                                           Eng #1 Dz
 2       2     25397.0                                           Eng #2 Dz
 2       3     25397.0                                           Eng #3 Dz
 2       4     25397.0                                           Eng #4 Dz
 2       5     25397.0                                           Eng #5 Dz
 2       6     25397.0                                           Eng #6 Dz
 2       7     25397.0                                           Eng #7 Dz
 2       8     25397.0                                           Eng #8 Dz
 1       9     30.0                                              Yaw Rate r
 2      10    -1551.5                                            Ydd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    +1551.5                                            Vehi Mass
 2       3    -19.92                                             Qbar.Sref.Cyb
 3       2     0.05                                              Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (deg2rad)
............................
Definitions of Inputs  =  10
Engine # 1 DZ Deflection in (rad)
Engine # 2 DZ Deflection in (rad)
Engine # 3 DZ Deflection in (rad)
Engine # 4 DZ Deflection in (rad)
Engine # 5 DZ Deflection in (rad)
Engine # 6 DZ Deflection in (rad)
Engine # 7 DZ Deflection in (rad)
Engine # 8 DZ Deflection in (rad)
Vehicle Yaw Rate      (rad/sec)                                            
Lateral Accelerat. Ny (ft/sec^2)                                                
 
Definitions of Outputs =   1
Beta Estimate in (rad)
---------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Integrator
Continuous
TF. Block #  1    1/s                                            Order of Numer, Denom=  0  1
Numer 0.0         1.0      
Denom 1.0         0.0      
......................................................
Block #, from Input #, Gain
  1  1    1.0                             
...........................
Outpt #, from Block #, Gain
  1  1    1.0
...........................
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Low Pass Filters
Continuous
TF. Block #  1 Roll Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         900.0
Denom 1.0         39.0        900.0
TF. Block #  2 Ptch Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0        1444.0
Denom 1.0         49.4       1444.0
TF. Block #  3 Yaw Low-Pass                                      Order of Numer, Denom=  0  2
Numer 0.0         0.0        1444.0
Denom 1.0         49.4       1444.0
TF. Block #  4 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  5 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  6 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
......................................................
Block #, from Input #, Gain
 1       1        1.0                                            
 2       2        1.0                                            
 3       3        1.0                                            
............................
Block #, from Block #, Gain
 4       1        1.0                                 
 5       2        1.0                                 
 6       3        1.0                                 
............................
Outpt #, from Block #, Gain
 1       4        1.0                                            DP_TVC
 2       5        1.0                                            DQ_TVC
 3       6        1.0                                            DR_TVC
............................
Definitions of Inputs  =   3
Roll   Filter Input
Pitch  Filter Input
Yaw    Filter Input
 
Definitions of Outputs =   3
Roll   Filter Output DP_tvc
Pitch  Filter Output DQ_tvc
Yaw    Filter Output DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Flight Control System
! Combine the Filters, Gains and Alpha/Beta Estimators. The Controller
! in Pitch  uses state-feedback from: [Theta, q, Alpha, Theta_Integral]
! in Yaw it uses state-feedback from: [Psi,   r, Beta,  & Psi_Integral]
!
Titles of Systems to be Combined
Title 1 Alpha Estimator
Title 2 Beta Estimator
Title 3 Low Pass Filters
Title 4 Integrator
Title 5 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                                   to Alfa Estimator
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                        Pitch Gimbal Deflects DY (1-8)
System Input  2 to Subsystem  1, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  1, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  1, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  1, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  1, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  1, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  1, Input  8, Gain= 1.00000            
System Input 21 to Subsystem  1, Input  9, Gain= 1.00000                                        Pitch Rate Q
System Input 23 to Subsystem  1, Input 10, Gain= 1.00000                                        NZ Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   to Beta Estimator
System Input  9 to Subsystem  2, Input  1, Gain= 1.00000                                        Yaw Gimbal Deflects DZ (1-8)
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  2, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  2, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  2, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  2, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  2, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  2, Input  8, Gain= 1.00000            
System Input 22 to Subsystem  2, Input  9, Gain= 1.00000                                        Yaw Rate R
System Input 24 to Subsystem  2, Input 10, Gain= 1.00000                                        NY Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   to Low-Pass Filters 
System Input 17 to Subsystem  3, Input  1, Gain= 2.5                                            KL_phi
System Input 18 to Subsystem  3, Input  2, Gain= 3.7                                            KM_theta
System Input 19 to Subsystem  3, Input  3, Gain= 3.7                                            KN_psi
System Input 20 to Subsystem  3, Input  1, Gain= 2.2                                            KL_p
System Input 21 to Subsystem  3, Input  2, Gain= 2.65                                           KM_q
System Input 22 to Subsystem  3, Input  3, Gain= 2.65                                           KN_r
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                                   to Integrator-4
System Input 18 to Subsystem  4, Input  1, Gain= 1.0                                            Theta
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                                   to Integrator-5
System Input 19 to Subsystem  5, Input  1, Gain= 1.0                                            Psi
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Alfa Estim to Filters
Subsystem  1, Output  1 to Subsystem  3, Input  2, Gain= 0.025                                  KM_alfa
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                                         Beta Estim to Filters
Subsystem  2, Output  1 to Subsystem  3, Input  3, Gain=-0.025                                  KN_beta= - Km_alfa
..............................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  3                                                         Theta-int to Low-Pass
Subsystem  4, Output  1 to Subsystem  3, Input  2, Gain= 0.7                                    KM_thint
..............................................................................
SUBSYSTEM NO  5 GOES TO SUBSYSTEM NO  3                                                         Psi-int to to Low-Pass
Subsystem  5, Output  1 to Subsystem  3, Input  3, Gain= 0.7                                    KN_psint
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                from Low-Pass Filters 
System Output  1 from Subsystem  3, Output  1, Gain= -1.0                                       DP_tvc
System Output  2 from Subsystem  3, Output  2, Gain= -1.0                                       DQ_tvc
System Output  3 from Subsystem  3, Output  3, Gain= -1.0                                       DR_tvc
..............................................................................
Definitions of Inputs  =  24
Engine Pitch Deflect Comd delta y_1 (rad)  
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)  
Roll  Attitude Error (rad)                  
Pitch Attitude Error (rad)
Yaw   Attitude Error (rad)
Roll  Rate (rad/sec)                        
Pitch Rate (rad/sec)
Yaw   Rate (rad/sec)
Normal  Acceleration NZ (ft/sec^2)         
Lateral Acceleration NY (ft/sec^2)         
 
Definitions of Outputs =   3
Roll  FCS Demand DP_tvc
Pitch FCS Demand DQ_tvc
Yaw   FCS Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Closed-Loop System
! Combines the Plant Model with the Flight Control System in
! Closed-Loop form
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=166 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
System Input  1 to Subsystem  1, Input 17, Gain= -1.0                                                      Roll Command
System Input  2 to Subsystem  1, Input 18, Gain= -1.0                                                      Ptch Command
System Input  3 to Subsystem  1, Input 19, Gain= -1.0                                                      Yaw  Command
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehi
System Input  4 to Subsystem  2, Input 17, Gain=  1.0                                                      Wind Gust
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    FCS
Via Matrix +TVC                                                                                            DY(8), DZ(8)
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                                    FCS to Vehi
Via Matrix +TVC                                                                                            DY(8), DZ(8)                                                                     
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                           Vehicle Outputs
Via Matrix +I32                                                                     
..............................................................................
Definitions of Inputs  =   4
Roll  Attitude Command (rad)  
Pitch Attitude Command (rad)  
Yaw   Attitude Command (rad)  
Wind-Gust Velocity (feet/sec)

Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Open-Loop System
! Combines the Plant Model with the Flight Control System in
! Open-Loop config
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=166 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehicle
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           Vehicle Outputs
Via Matrix +I03                                                                     
..............................................................................
Definitions of Inputs  =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc

Definitions of Outputs =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Roll Loop Opened, Others Closed
! Roll Loop Opened for Roll Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                                       Roll Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  1, Gain= -1.0                                                  DP_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw Closed
..............................................................................
Definitions of Inputs  =   1
Roll Control Demand DP_tvc 

Definitions of Outputs =   1
Roll Control Demand DP_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Pitch Loop Opened, Others Closed
! Pitch Loop Opened for Pitch Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  2, Gain= 1.0                                                       Pitch Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  2, Gain= -1.0                                                  DQ_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw  Closed
..............................................................................
Definitions of Inputs  =   1
Pitch Control Demand DQ_tvc 

Definitions of Outputs =   1
Pitch Control Demand DQ_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Yaw Loop Opened, Others Closed
! Roll Loop Opened for Yaw Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  3, Gain= 1.0                                                       Yaw Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  3, Gain= -1.0                                                  DR_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll  Closed
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
..............................................................................
Definitions of Inputs  =   1
Yaw Control Demand DR_tvc 

Definitions of Outputs =   1
Yaw Control Demand DR_tvc 
--------------------------------------------------------------------------------------------------------------------------------
                            CONVERT TO MATLAB DATA
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=166.0 sec 
Matrix TVC
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=166.0 sec 
System
flex_vehicle.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Flight Control System
System
fcs.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model at T=166 sec, Vehicle/ Actuators
System
plant.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Closed-Loop System
System
closed_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Open-Loop System
System
open_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Roll Loop Opened, Others Closed
System
roll_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Loop Opened, Others Closed
System
pitch_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Yaw Loop Opened, Others Closed
System
yaw_open.m
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 20% Full
First Stage Flex Modes at 20% Full Tanks
! Flex Modes, First Stage 20% Full Tanks from files: Stg1_20%.Mod, Stg1_20%.Nod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    40.922       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.21177D-01   0.14960D+00  -0.13133D-03  -0.94302D-05   0.53677D-05  -0.88736D-02
S1 Engine No:2 +Y-Z               1152     0.87146D-02   0.14959D+00  -0.12636D-03   0.10121D-05   0.66796D-05  -0.89243D-02
S1 Engine No:3 -Y-Z               1153    -0.89483D-02   0.14959D+00  -0.13452D-03   0.79430D-06  -0.23246D-04  -0.89242D-02
S1 Engine No:4 -Y-Z               1154    -0.21435D-01   0.14960D+00  -0.12963D-03  -0.87798D-05  -0.22964D-04  -0.88736D-02
S1 Engine No:5 -Y+Z               1155    -0.21453D-01   0.14960D+00  -0.12958D-03   0.96340D-05   0.48954D-05  -0.88744D-02
S1 Engine No:6 -Y+Z               1156    -0.89894D-02   0.14959D+00  -0.12611D-03  -0.23074D-05   0.71262D-05  -0.89246D-02
S1 Engine No:7 +Y+Z               1157     0.86742D-02   0.14959D+00  -0.13610D-03  -0.15631D-05  -0.24008D-04  -0.89243D-02
S1 Engine No:8 +Y+Z               1158     0.21161D-01   0.14960D+00  -0.13152D-03   0.99480D-05  -0.22148D-04  -0.88738D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04  -0.13316D-06   0.84138D-05   0.88787D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04  -0.13316D-06   0.84138D-05   0.88787D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04  -0.13316D-06   0.84138D-05   0.88787D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.13327D-03  -0.11454D+00   0.11908D-03  -0.10497D-06  -0.36106D-05  -0.40292D-02
Fuel Slosh Mass Locat.             600    -0.13688D-03   0.91766D-01  -0.75127D-04  -0.84936D-07  -0.84336D-05  -0.87972D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.28882D-03   0.15334D+00  -0.13828D-03   0.10457D-03  -0.13691D-04  -0.11764D-01

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    41.758       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.10042D-01   0.14504D-03   0.16708D+00   0.11821D-05   0.10166D-01  -0.25278D-04
S1 Engine No:2 +Y-Z               1152    -0.24264D-01   0.14045D-03   0.16709D+00  -0.96707D-05   0.10108D-01  -0.24275D-04
S1 Engine No:3 -Y-Z               1153    -0.24279D-01   0.14062D-03   0.16709D+00   0.10166D-04   0.10108D-01   0.88027D-05
S1 Engine No:4 -Y-Z               1154    -0.10079D-01   0.13598D-03   0.16708D+00  -0.13720D-05   0.10166D-01   0.10273D-04
S1 Engine No:5 -Y+Z               1155     0.10042D-01   0.14598D-03   0.16708D+00  -0.16984D-05   0.10166D-01  -0.25480D-04
S1 Engine No:6 -Y+Z               1156     0.24264D-01   0.14090D-03   0.16709D+00   0.11082D-04   0.10108D-01  -0.23503D-04
S1 Engine No:7 +Y+Z               1157     0.24279D-01   0.14082D-03   0.16709D+00  -0.10500D-04   0.10108D-01   0.85625D-05
S1 Engine No:8 +Y+Z               1158     0.10078D-01   0.13573D-03   0.16708D+00   0.13466D-05   0.10166D-01   0.10229D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01  -0.50983D-07  -0.99569D-02   0.76210D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01  -0.50983D-07  -0.99569D-02   0.76210D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01  -0.50983D-07  -0.99569D-02   0.76210D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.12688D-06  -0.88988D-04  -0.13285D+00   0.16117D-07   0.45113D-02  -0.36970D-05
Fuel Slosh Mass Locat.             600    -0.13550D-06   0.91268D-04   0.10119D+00   0.66016D-07   0.10018D-01  -0.75299D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.34799D-06   0.13928D-03   0.17139D+00  -0.74672D-04   0.13447D-01  -0.75683D-05

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    48.359       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.16054D-01   0.93888D-01   0.27092D-04  -0.82034D-05   0.11684D-04  -0.65557D-02
S1 Engine No:2 +Y-Z               1152     0.68326D-02   0.93880D-01   0.31445D-04   0.87774D-06   0.12452D-04  -0.65972D-02
S1 Engine No:3 -Y-Z               1153    -0.62255D-02   0.93880D-01   0.24412D-04   0.70726D-06  -0.10831D-04  -0.65969D-02
S1 Engine No:4 -Y-Z               1154    -0.15444D-01   0.93888D-01   0.28683D-04  -0.76258D-05  -0.10435D-04  -0.65549D-02
S1 Engine No:5 -Y+Z               1155    -0.15443D-01   0.93886D-01   0.28604D-04   0.84290D-05   0.11611D-04  -0.65555D-02
S1 Engine No:6 -Y+Z               1156    -0.62208D-02   0.93879D-01   0.31665D-04  -0.20203D-05   0.13658D-04  -0.65974D-02
S1 Engine No:7 +Y+Z               1157     0.68379D-02   0.93879D-01   0.23048D-04  -0.13596D-05  -0.10713D-04  -0.65972D-02
S1 Engine No:8 +Y+Z               1158     0.16057D-01   0.93887D-01   0.27078D-04   0.87064D-05  -0.93443D-05  -0.65557D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05  -0.12234D-06  -0.11356D-05   0.55400D-02
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05  -0.12234D-06  -0.11356D-05   0.55400D-02
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05  -0.12234D-06  -0.11356D-05   0.55400D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.29721D-03  -0.95071D-01  -0.62860D-05  -0.85984D-07   0.70717D-06  -0.24763D-02
Fuel Slosh Mass Locat.             600     0.30479D-03   0.51043D-01   0.21181D-04  -0.60346D-07   0.10095D-05  -0.64814D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.16480D-03   0.97383D-01   0.22450D-04   0.99028D-04  -0.22602D-05  -0.92411D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    54.641       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.45685D-02   0.25308D-04   0.59146D-01   0.46016D-06   0.46177D-02  -0.96554D-05
S1 Engine No:2 +Y-Z               1152    -0.11023D-01   0.22195D-04   0.59152D-01  -0.60234D-05   0.45862D-02  -0.91790D-05
S1 Engine No:3 -Y-Z               1153    -0.11025D-01   0.22482D-04   0.59152D-01   0.58489D-05   0.45863D-02   0.73415D-05
S1 Engine No:4 -Y-Z               1154    -0.45727D-02   0.20023D-04   0.59147D-01  -0.10668D-05   0.46178D-02   0.80803D-05
S1 Engine No:5 -Y+Z               1155     0.45688D-02   0.26394D-04   0.59147D-01  -0.12779D-05   0.46181D-02  -0.97824D-05
S1 Engine No:6 -Y+Z               1156     0.11024D-01   0.23654D-04   0.59152D-01   0.64298D-05   0.45862D-02  -0.86880D-05
S1 Engine No:7 +Y+Z               1157     0.11025D-01   0.23787D-04   0.59152D-01  -0.65504D-05   0.45860D-02   0.71899D-05
S1 Engine No:8 +Y+Z               1158     0.45727D-02   0.20344D-04   0.59146D-01   0.55645D-06   0.46178D-02   0.80527D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02  -0.24516D-06  -0.31572D-02   0.98976D-06
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02  -0.24516D-06  -0.31572D-02   0.98976D-06
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02  -0.24516D-06  -0.31572D-02   0.98976D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.21151D-07  -0.61299D-05  -0.69013D-01  -0.21820D-06   0.14102D-02  -0.60904D-06
Fuel Slosh Mass Locat.             600     0.15784D-07   0.17489D-04   0.29102D-01  -0.20200D-06   0.45227D-02  -0.85109D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.10266D-06   0.17061D-04   0.62050D-01  -0.51830D-04   0.68070D-02   0.27982D-05

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    78.979       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.27746D-01   0.11006D+00  -0.72966D-02  -0.25224D-04  -0.73172D-03  -0.11216D-01
S1 Engine No:2 +Y-Z               1152     0.12983D-01   0.11003D+00  -0.72848D-02   0.46234D-05  -0.72280D-03  -0.11324D-01
S1 Engine No:3 -Y-Z               1153    -0.94413D-02   0.11003D+00  -0.73064D-02   0.96890D-06  -0.76706D-03  -0.11326D-01
S1 Engine No:4 -Y-Z               1154    -0.26305D-01   0.11006D+00  -0.72919D-02  -0.22799D-04  -0.77470D-03  -0.11219D-01
S1 Engine No:5 -Y+Z               1155    -0.27799D-01   0.11005D+00  -0.72934D-02   0.26978D-04  -0.73308D-03  -0.11218D-01
S1 Engine No:6 -Y+Z               1156    -0.13033D-01   0.11003D+00  -0.72850D-02  -0.79184D-05  -0.72091D-03  -0.11325D-01
S1 Engine No:7 +Y+Z               1157     0.93936D-02   0.11003D+00  -0.73106D-02  -0.22976D-05  -0.76885D-03  -0.11327D-01
S1 Engine No:8 +Y+Z               1158     0.26258D-01   0.11006D+00  -0.72955D-02   0.27463D-04  -0.77194D-03  -0.11220D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02  -0.64033D-06  -0.30289D-03  -0.45233D-02
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02  -0.64033D-06  -0.30289D-03  -0.45233D-02
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02  -0.64033D-06  -0.30289D-03  -0.45233D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.77610D-05  -0.15360D+00   0.10207D-01  -0.13663D-06   0.31579D-04   0.46290D-03
Fuel Slosh Mass Locat.             600    -0.23260D-04   0.35700D-01  -0.23562D-02   0.20230D-06  -0.72472D-03  -0.10909D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.72574D-03   0.12592D+00  -0.83679D-02   0.49966D-03  -0.15425D-02  -0.23041D-01

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    79.066       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.94138D-02   0.74901D-02   0.11120D+00   0.74812D-06   0.11343D-01  -0.77818D-03
S1 Engine No:2 +Y-Z               1152    -0.26317D-01   0.74770D-02   0.11123D+00  -0.22543D-04   0.11236D-01  -0.78445D-03
S1 Engine No:3 -Y-Z               1153    -0.27826D-01   0.74791D-02   0.11123D+00   0.23633D-04   0.11233D-01  -0.73878D-03
S1 Engine No:4 -Y-Z               1154    -0.13048D-01   0.74701D-02   0.11120D+00  -0.51535D-05   0.11340D-01  -0.72931D-03
S1 Engine No:5 -Y+Z               1155     0.94116D-02   0.74928D-02   0.11120D+00  -0.26544D-05   0.11344D-01  -0.77881D-03
S1 Engine No:6 -Y+Z               1156     0.26314D-01   0.74794D-02   0.11123D+00   0.25488D-04   0.11236D-01  -0.78245D-03
S1 Engine No:7 +Y+Z               1157     0.27821D-01   0.74809D-02   0.11123D+00  -0.25254D-04   0.11232D-01  -0.73943D-03
S1 Engine No:8 +Y+Z               1158     0.13045D-01   0.74699D-02   0.11120D+00   0.47081D-05   0.11341D-01  -0.72948D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01  -0.13656D-06   0.45017D-02  -0.29986D-03
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01  -0.13656D-06   0.45017D-02  -0.29986D-03
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01  -0.13656D-06   0.45017D-02  -0.29986D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.53356D-06  -0.10300D-01  -0.15349D+00  -0.12330D-06  -0.43104D-03   0.28136D-04
Fuel Slosh Mass Locat.             600    -0.15318D-05   0.24815D-02   0.36746D-01  -0.11826D-06   0.10928D-01  -0.73355D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.45408D-04   0.84536D-02   0.12596D+00  -0.24703D-03   0.22286D-01  -0.14862D-02

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    107.97       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.68325D-06   0.45868D-02   0.11079D-01   0.46439D-02  -0.95764D-06   0.19456D-06
S1 Engine No:2 +Y-Z               1152     0.21528D-05   0.11080D-01   0.45855D-02   0.46439D-02  -0.10666D-05   0.73914D-07
S1 Engine No:3 -Y-Z               1153     0.22503D-05   0.11080D-01  -0.45969D-02   0.46439D-02  -0.80180D-06   0.75487D-07
S1 Engine No:4 -Y-Z               1154     0.10811D-05   0.45868D-02  -0.11090D-01   0.46439D-02  -0.93583D-06   0.18106D-06
S1 Engine No:5 -Y+Z               1155    -0.83379D-06  -0.45957D-02  -0.11090D-01   0.46439D-02  -0.94475D-06  -0.72433D-07
S1 Engine No:6 -Y+Z               1156    -0.22107D-05  -0.11089D-01  -0.45969D-02   0.46439D-02  -0.82543D-06   0.68502D-07
S1 Engine No:7 +Y+Z               1157    -0.24043D-05  -0.11089D-01   0.45855D-02   0.46439D-02  -0.10675D-05   0.67109D-07
S1 Engine No:8 +Y+Z               1158    -0.11429D-05  -0.45957D-02   0.11079D-01   0.46439D-02  -0.94398D-06  -0.59196D-07

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05   0.33598D-02  -0.12137D-05  -0.23036D-06
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05   0.33598D-02  -0.12137D-05  -0.23036D-06
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05   0.33598D-02  -0.12137D-05  -0.23036D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.84570D-08   0.11832D-05   0.94382D-05   0.39685D-02   0.44412D-06   0.17657D-06
Fuel Slosh Mass Locat.             600    -0.42386D-07  -0.39234D-05   0.53697D-06   0.45822D-02  -0.88120D-06   0.87716D-07

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.81939D-06   0.36618D-05  -0.12329D-04   0.53972D-02  -0.64873D-05  -0.63389D-05

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    118.66       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.18348D-01   0.39238D-01  -0.21351D-02  -0.13115D-04  -0.47166D-03  -0.76390D-02
S1 Engine No:2 +Y-Z               1152     0.83002D-02   0.39225D-01  -0.21342D-02   0.99830D-05  -0.47009D-03  -0.76729D-02
S1 Engine No:3 -Y-Z               1153    -0.68687D-02   0.39225D-01  -0.21618D-02   0.74214D-05  -0.44059D-03  -0.76726D-02
S1 Engine No:4 -Y-Z               1154    -0.18196D-01   0.39238D-01  -0.21591D-02  -0.10735D-04  -0.44640D-03  -0.76408D-02
S1 Engine No:5 -Y+Z               1155    -0.19108D-01   0.39218D-01  -0.21634D-02   0.28057D-04  -0.47503D-03  -0.76451D-02
S1 Engine No:6 -Y+Z               1156    -0.90564D-02   0.39189D-01  -0.21475D-02  -0.11081D-06  -0.47270D-03  -0.76764D-02
S1 Engine No:7 +Y+Z               1157     0.61149D-02   0.39189D-01  -0.21533D-02   0.43444D-05  -0.44686D-03  -0.76709D-02
S1 Engine No:8 +Y+Z               1158     0.17443D-01   0.39222D-01  -0.21314D-02   0.28730D-04  -0.44555D-03  -0.76368D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02  -0.41551D-05  -0.83762D-03  -0.13685D-01
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02  -0.41551D-05  -0.83762D-03  -0.13685D-01
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02  -0.41551D-05  -0.83762D-03  -0.13685D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.17902D-03  -0.61662D-01   0.36433D-02   0.24540D-05   0.30205D-03   0.48654D-02
Fuel Slosh Mass Locat.             600    -0.35770D-03  -0.11461D-01   0.88105D-03   0.64460D-05  -0.42097D-03  -0.70529D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.32358D-02   0.95378D-01  -0.59402D-02   0.20245D-02  -0.31440D-02  -0.47554D-01

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    119.29       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.69052D-02  -0.34408D-02  -0.51272D-01   0.60010D-06  -0.82111D-02   0.51200D-03
S1 Engine No:2 +Y-Z               1152     0.19072D-01  -0.34248D-02  -0.51300D-01   0.24426D-04  -0.81430D-02   0.51830D-03
S1 Engine No:3 -Y-Z               1153     0.20100D-01  -0.34294D-02  -0.51300D-01  -0.23006D-04  -0.81432D-02   0.52008D-03
S1 Engine No:4 -Y-Z               1154     0.93784D-02  -0.34220D-02  -0.51277D-01   0.69791D-05  -0.82112D-02   0.51467D-03
S1 Engine No:5 -Y+Z               1155    -0.68703D-02  -0.34470D-02  -0.51277D-01   0.44682D-05  -0.82123D-02   0.51296D-03
S1 Engine No:6 -Y+Z               1156    -0.19036D-01  -0.34344D-02  -0.51304D-01  -0.25339D-04  -0.81425D-02   0.51590D-03
S1 Engine No:7 +Y+Z               1157    -0.20061D-01  -0.34382D-02  -0.51301D-01   0.27720D-04  -0.81416D-02   0.52076D-03
S1 Engine No:8 +Y+Z               1158    -0.93421D-02  -0.34243D-02  -0.51272D-01  -0.35912D-05  -0.82114D-02   0.51468D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01  -0.14226D-05  -0.14072D-01   0.87086D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01  -0.14226D-05  -0.14072D-01   0.87086D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01  -0.14226D-05  -0.14072D-01   0.87086D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.97389D-05   0.43022D-02   0.67358D-01   0.36378D-06   0.47519D-02  -0.28968D-03
Fuel Slosh Mass Locat.             600     0.17259D-04   0.99565D-05   0.31459D-02   0.14172D-05  -0.75980D-02   0.48110D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.12631D-03  -0.55260D-02  -0.91041D-01   0.78224D-03  -0.36744D-01   0.20340D-02

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    137.86       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13529D-01  -0.11918D+00   0.98327D-02   0.15640D-03   0.22816D-03   0.40548D-02
S1 Engine No:2 +Y-Z               1152    -0.76710D-02  -0.11901D+00   0.97015D-02   0.45341D-04   0.18445D-03   0.45671D-02
S1 Engine No:3 -Y-Z               1153     0.15562D-02  -0.11901D+00   0.96606D-02   0.60460D-04   0.50838D-03   0.45751D-02
S1 Engine No:4 -Y-Z               1154     0.84526D-02  -0.11918D+00   0.95180D-02   0.14839D-03   0.53612D-03   0.40436D-02
S1 Engine No:5 -Y+Z               1155     0.92151D-02  -0.11928D+00   0.95122D-02  -0.32608D-04   0.21646D-03   0.40236D-02
S1 Engine No:6 -Y+Z               1156     0.33468D-02  -0.11930D+00   0.95723D-02   0.95294D-04   0.14237D-03   0.45557D-02
S1 Engine No:7 +Y+Z               1157    -0.58881D-02  -0.11930D+00   0.98011D-02   0.73031D-04   0.47719D-03   0.45923D-02
S1 Engine No:8 +Y+Z               1158    -0.12784D-01  -0.11930D+00   0.98382D-02  -0.32995D-04   0.51137D-03   0.40818D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04  -0.25920D-04   0.34897D-03   0.42708D-02
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04  -0.25920D-04   0.34897D-03   0.42708D-02
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04  -0.25920D-04   0.34897D-03   0.42708D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.87747D-03   0.61775D-01  -0.50183D-02   0.29689D-04   0.11798D-03   0.14599D-02
Fuel Slosh Mass Locat.             600    -0.20277D-02  -0.86149D-01   0.69928D-02   0.61050D-04   0.38958D-03   0.47916D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.15021D-01   0.11283D+00  -0.91412D-02   0.92557D-02  -0.12686D-01  -0.15650D+00

MODE# 11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    150.07       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.18421D-02  -0.89909D-02  -0.10980D+00  -0.67746D-04  -0.26788D-02   0.37357D-03
S1 Engine No:2 +Y-Z               1152     0.58836D-02  -0.90290D-02  -0.10979D+00   0.25656D-04  -0.20789D-02   0.40954D-03
S1 Engine No:3 -Y-Z               1153     0.63322D-02  -0.90233D-02  -0.10965D+00  -0.15786D-03  -0.20477D-02   0.24672D-04
S1 Engine No:4 -Y-Z               1154     0.28938D-02  -0.88994D-02  -0.10949D+00  -0.40620D-04  -0.26495D-02  -0.41018D-04
S1 Engine No:5 -Y+Z               1155    -0.26064D-02  -0.88733D-02  -0.10949D+00  -0.54034D-04  -0.26855D-02   0.36800D-03
S1 Engine No:6 -Y+Z               1156    -0.66456D-02  -0.87319D-02  -0.10967D+00  -0.16276D-03  -0.20856D-02   0.39970D-03
S1 Engine No:7 +Y+Z               1157    -0.70879D-02  -0.87246D-02  -0.10979D+00   0.35203D-04  -0.20519D-02   0.29994D-04
S1 Engine No:8 +Y+Z               1158    -0.36547D-02  -0.87725D-02  -0.10979D+00  -0.85367D-04  -0.26536D-02  -0.32824D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02   0.21368D-04  -0.30372D-02   0.24540D-03
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02   0.21368D-04  -0.30372D-02   0.24540D-03
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02   0.21368D-04  -0.30372D-02   0.24540D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.17614D-03   0.45243D-02   0.55883D-01  -0.32063D-04  -0.24332D-02   0.19708D-03
Fuel Slosh Mass Locat.             600    -0.35769D-03  -0.71723D-02  -0.88581D-01  -0.60629D-04  -0.31170D-02   0.25234D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.17496D-02   0.14253D-01   0.17558D+00  -0.62749D-02   0.19573D+00  -0.15899D-01

MODE# 12/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    182.92       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.16052D-04  -0.91728D-01  -0.22101D+00  -0.92639D-01  -0.54512D-05  -0.15880D-04
S1 Engine No:2 +Y-Z               1152     0.12143D-04  -0.22127D+00  -0.91472D-01  -0.92640D-01  -0.53810D-08  -0.64922D-05
S1 Engine No:3 -Y-Z               1153     0.40023D-05  -0.22127D+00   0.91728D-01  -0.92640D-01  -0.14092D-04  -0.56674D-05
S1 Engine No:4 -Y-Z               1154    -0.14758D-04  -0.91729D-01   0.22127D+00  -0.92640D-01  -0.51679D-05  -0.14171D-04
S1 Engine No:5 -Y+Z               1155    -0.22150D-04   0.91471D-01   0.22127D+00  -0.92640D-01  -0.62069D-05  -0.25580D-06
S1 Engine No:6 -Y+Z               1156    -0.24044D-04   0.22101D+00   0.91728D-01  -0.92640D-01  -0.14453D-04  -0.63692D-05
S1 Engine No:7 +Y+Z               1157    -0.99118D-05   0.22101D+00  -0.91471D-01  -0.92640D-01   0.14650D-05  -0.51780D-05
S1 Engine No:8 +Y+Z               1158     0.30811D-05   0.91470D-01  -0.22101D+00  -0.92640D-01  -0.48935D-05   0.21400D-06

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04   0.21989D-01   0.48624D-05   0.51151D-05
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04   0.21989D-01   0.48624D-05   0.51151D-05
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04   0.21989D-01   0.48624D-05   0.51151D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.27777D-05   0.10758D-03  -0.10305D-03  -0.54974D-01   0.99894D-05   0.10399D-04
Fuel Slosh Mass Locat.             600    -0.45818D-05  -0.16024D-03   0.15608D-03  -0.89100D-01  -0.32438D-05  -0.36702D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.45574D-05   0.50733D-03  -0.45925D-03  -0.15652D+00  -0.34514D-03  -0.38507D-03

MODE# 13/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    209.92       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.37565D-01   0.10180D+00  -0.49475D-02  -0.11924D-03  -0.82676D-03  -0.15372D-01
S1 Engine No:2 +Y-Z               1152     0.16762D-01   0.10170D+00  -0.49477D-02   0.11067D-03  -0.79661D-03  -0.15894D-01
S1 Engine No:3 -Y-Z               1153    -0.14762D-01   0.10170D+00  -0.52552D-02   0.87816D-04  -0.74238D-03  -0.15904D-01
S1 Engine No:4 -Y-Z               1154    -0.37818D-01   0.10180D+00  -0.52423D-02  -0.96025D-04  -0.80498D-03  -0.15400D-01
S1 Engine No:5 -Y+Z               1155    -0.39473D-01   0.10159D+00  -0.52590D-02   0.28019D-03  -0.85631D-03  -0.15422D-01
S1 Engine No:6 -Y+Z               1156    -0.18638D-01   0.10131D+00  -0.50904D-02  -0.25153D-06  -0.81479D-03  -0.15925D-01
S1 Engine No:7 +Y+Z               1157     0.12912D-01   0.10131D+00  -0.51582D-02   0.41830D-04  -0.79108D-03  -0.15894D-01
S1 Engine No:8 +Y+Z               1158     0.35966D-01   0.10163D+00  -0.49362D-02   0.28580D-03  -0.79262D-03  -0.15368D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02  -0.14657D-04   0.25667D-03   0.50778D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02  -0.14657D-04   0.25667D-03   0.50778D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02  -0.14657D-04   0.25667D-03   0.50778D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.75031D-03   0.48246D-01  -0.25503D-02   0.48919D-04   0.70139D-03   0.13651D-01
Fuel Slosh Mass Locat.             600    -0.89617D-03  -0.70780D-02   0.46299D-03   0.71485D-04  -0.69130D-03  -0.13496D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.24129D-02   0.57956D-01  -0.34540D-02  -0.28346D-02   0.16589D-03   0.11206D-01

MODE# 14/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    210.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13992D-01   0.54396D-02   0.10515D+00  -0.40729D-04   0.15928D-01  -0.77290D-03
