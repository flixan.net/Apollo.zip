S1 Engine No:8 +Y+Z               1158     0.10664D-01   0.70938D-01  -0.14765D+00  -0.10874D-02  -0.14536D-01  -0.17116D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01  -0.52292D-07  -0.10041D-02  -0.52972D-03
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01  -0.52292D-07  -0.10041D-02  -0.52972D-03
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01  -0.52292D-07  -0.10041D-02  -0.52972D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01
Stage-2 Tank Top, IMU Locat.     40015     0.15634D-03   0.54484D-02  -0.10351D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.83882D-03  -0.17814D-01   0.33784D-01   0.13307D-06   0.28526D-02   0.15035D-02
Fuel Slosh Mass Locat.             600     0.18757D-02   0.46258D-01  -0.87687D-01  -0.12178D-05   0.75188D-02   0.39570D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.27411D-04  -0.31296D-03   0.51136D-03   0.15654D-07  -0.23532D-02  -0.12262D-02
----------------------------------------------------------------------------------------------------------------------------
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
