BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=140 sec
! This batch set creates dynamic models for Control Analysis at T=140 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=140.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=140.0 sec 
Actuator Model   : Stage-1 Linear Actuator
!
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=140.0 sec            
To Matlab Format : Mixing Logic for First Stage Model, at T=140.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=140.0 sec                                       
! This is a Launch Vehicle Control Analysis Model at t=140 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 100% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.012 .
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   2137.92       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   16371.1      0.198735E+07  0.198639E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   65.3890       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   4.27400       4543.22       46.8400       145222.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   88.1929       105.950       0.0          -0.115100    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   1.06800       0.00          0.00000       0.0
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0           35.22         0.00000       0.0          -0.3077        0.0
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.00         90.00                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.4150       7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.970986      0.00148      -0.57853E-04   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0          -0.077         0.00000       0.0           0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.0788       -0.077         0.00000       0.0           0.00000       0.00000     -0.174522E-06
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.151063     -0.17200       0.00000       0.0           0.00000     -0.147012E-04   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0           0.1700        0.00000       0.00000       0.00000      0.204000E-01

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       2.49450      -1.03320    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       1.03320      -2.49450    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -1.03320      -2.49450    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -2.49450      -1.03320    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -2.49450       1.03320    
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000      -1.03320       2.49450    
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       1.03320       2.49450    
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   25392.3       25392.3       
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0000       2.49450       1.03320    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438    0.000      0.000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438    0.000      0.000    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438    0.000      0.000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000       

Number of Slosh Modes                                                                    :  2
LOX Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   540.1   3.11   3.11   0.01  0.01  48.21   0.0  0.0  
LH2 Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   186.1   3.11   3.11   0.01  0.01  19.56   0.0  0.0 

Number of Bending Modes                                                                  : 32
First Stage Flex Modes at 20% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=140.0 sec 
! Thrust Vector Control Matrix at t=140 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=140.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=140.0 sec 
Matrix TVC
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=140.0 sec 
System
flex_vehicle.m
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
--------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 20% Full
First Stage Flex Modes at 20% Full Tanks
! Flex Modes, First Stage 20% Full Tanks from files: Stg1_20%.Mod, Stg1_20%.Nod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    40.922       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.21177D-01   0.14960D+00  -0.13133D-03  -0.94302D-05   0.53677D-05  -0.88736D-02
S1 Engine No:2 +Y-Z               1152     0.87146D-02   0.14959D+00  -0.12636D-03   0.10121D-05   0.66796D-05  -0.89243D-02
S1 Engine No:3 -Y-Z               1153    -0.89483D-02   0.14959D+00  -0.13452D-03   0.79430D-06  -0.23246D-04  -0.89242D-02
S1 Engine No:4 -Y-Z               1154    -0.21435D-01   0.14960D+00  -0.12963D-03  -0.87798D-05  -0.22964D-04  -0.88736D-02
S1 Engine No:5 -Y+Z               1155    -0.21453D-01   0.14960D+00  -0.12958D-03   0.96340D-05   0.48954D-05  -0.88744D-02
S1 Engine No:6 -Y+Z               1156    -0.89894D-02   0.14959D+00  -0.12611D-03  -0.23074D-05   0.71262D-05  -0.89246D-02
S1 Engine No:7 +Y+Z               1157     0.86742D-02   0.14959D+00  -0.13610D-03  -0.15631D-05  -0.24008D-04  -0.89243D-02
S1 Engine No:8 +Y+Z               1158     0.21161D-01   0.14960D+00  -0.13152D-03   0.99480D-05  -0.22148D-04  -0.88738D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04  -0.13316D-06   0.84138D-05   0.88787D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04  -0.13316D-06   0.84138D-05   0.88787D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04  -0.13316D-06   0.84138D-05   0.88787D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.12910D-03   0.14836D-01  -0.12741D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.13327D-03  -0.11454D+00   0.11908D-03  -0.10497D-06  -0.36106D-05  -0.40292D-02
Fuel Slosh Mass Locat.             600    -0.13688D-03   0.91766D-01  -0.75127D-04  -0.84936D-07  -0.84336D-05  -0.87972D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.28882D-03   0.15334D+00  -0.13828D-03   0.10457D-03  -0.13691D-04  -0.11764D-01

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    41.758       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.10042D-01   0.14504D-03   0.16708D+00   0.11821D-05   0.10166D-01  -0.25278D-04
S1 Engine No:2 +Y-Z               1152    -0.24264D-01   0.14045D-03   0.16709D+00  -0.96707D-05   0.10108D-01  -0.24275D-04
S1 Engine No:3 -Y-Z               1153    -0.24279D-01   0.14062D-03   0.16709D+00   0.10166D-04   0.10108D-01   0.88027D-05
S1 Engine No:4 -Y-Z               1154    -0.10079D-01   0.13598D-03   0.16708D+00  -0.13720D-05   0.10166D-01   0.10273D-04
S1 Engine No:5 -Y+Z               1155     0.10042D-01   0.14598D-03   0.16708D+00  -0.16984D-05   0.10166D-01  -0.25480D-04
S1 Engine No:6 -Y+Z               1156     0.24264D-01   0.14090D-03   0.16709D+00   0.11082D-04   0.10108D-01  -0.23503D-04
S1 Engine No:7 +Y+Z               1157     0.24279D-01   0.14082D-03   0.16709D+00  -0.10500D-04   0.10108D-01   0.85625D-05
S1 Engine No:8 +Y+Z               1158     0.10078D-01   0.13573D-03   0.16708D+00   0.13466D-05   0.10166D-01   0.10229D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01  -0.50983D-07  -0.99569D-02   0.76210D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01  -0.50983D-07  -0.99569D-02   0.76210D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01  -0.50983D-07  -0.99569D-02   0.76210D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.12195D-06   0.12464D-04   0.14280D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.12688D-06  -0.88988D-04  -0.13285D+00   0.16117D-07   0.45113D-02  -0.36970D-05
Fuel Slosh Mass Locat.             600    -0.13550D-06   0.91268D-04   0.10119D+00   0.66016D-07   0.10018D-01  -0.75299D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.34799D-06   0.13928D-03   0.17139D+00  -0.74672D-04   0.13447D-01  -0.75683D-05

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    48.359       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.16054D-01   0.93888D-01   0.27092D-04  -0.82034D-05   0.11684D-04  -0.65557D-02
S1 Engine No:2 +Y-Z               1152     0.68326D-02   0.93880D-01   0.31445D-04   0.87774D-06   0.12452D-04  -0.65972D-02
S1 Engine No:3 -Y-Z               1153    -0.62255D-02   0.93880D-01   0.24412D-04   0.70726D-06  -0.10831D-04  -0.65969D-02
S1 Engine No:4 -Y-Z               1154    -0.15444D-01   0.93888D-01   0.28683D-04  -0.76258D-05  -0.10435D-04  -0.65549D-02
S1 Engine No:5 -Y+Z               1155    -0.15443D-01   0.93886D-01   0.28604D-04   0.84290D-05   0.11611D-04  -0.65555D-02
S1 Engine No:6 -Y+Z               1156    -0.62208D-02   0.93879D-01   0.31665D-04  -0.20203D-05   0.13658D-04  -0.65974D-02
S1 Engine No:7 +Y+Z               1157     0.68379D-02   0.93879D-01   0.23048D-04  -0.13596D-05  -0.10713D-04  -0.65972D-02
S1 Engine No:8 +Y+Z               1158     0.16057D-01   0.93887D-01   0.27078D-04   0.87064D-05  -0.93443D-05  -0.65557D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05  -0.12234D-06  -0.11356D-05   0.55400D-02
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05  -0.12234D-06  -0.11356D-05   0.55400D-02
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05  -0.12234D-06  -0.11356D-05   0.55400D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05
Stage-2 Tank Top, IMU Locat.     40015     0.28903D-03  -0.10366D-02   0.10303D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.29721D-03  -0.95071D-01  -0.62860D-05  -0.85984D-07   0.70717D-06  -0.24763D-02
Fuel Slosh Mass Locat.             600     0.30479D-03   0.51043D-01   0.21181D-04  -0.60346D-07   0.10095D-05  -0.64814D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.16480D-03   0.97383D-01   0.22450D-04   0.99028D-04  -0.22602D-05  -0.92411D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    54.641       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.45685D-02   0.25308D-04   0.59146D-01   0.46016D-06   0.46177D-02  -0.96554D-05
S1 Engine No:2 +Y-Z               1152    -0.11023D-01   0.22195D-04   0.59152D-01  -0.60234D-05   0.45862D-02  -0.91790D-05
S1 Engine No:3 -Y-Z               1153    -0.11025D-01   0.22482D-04   0.59152D-01   0.58489D-05   0.45863D-02   0.73415D-05
S1 Engine No:4 -Y-Z               1154    -0.45727D-02   0.20023D-04   0.59147D-01  -0.10668D-05   0.46178D-02   0.80803D-05
S1 Engine No:5 -Y+Z               1155     0.45688D-02   0.26394D-04   0.59147D-01  -0.12779D-05   0.46181D-02  -0.97824D-05
S1 Engine No:6 -Y+Z               1156     0.11024D-01   0.23654D-04   0.59152D-01   0.64298D-05   0.45862D-02  -0.86880D-05
S1 Engine No:7 +Y+Z               1157     0.11025D-01   0.23787D-04   0.59152D-01  -0.65504D-05   0.45860D-02   0.71899D-05
S1 Engine No:8 +Y+Z               1158     0.45727D-02   0.20344D-04   0.59146D-01   0.55645D-06   0.46178D-02   0.80527D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02  -0.24516D-06  -0.31572D-02   0.98976D-06
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02  -0.24516D-06  -0.31572D-02   0.98976D-06
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02  -0.24516D-06  -0.31572D-02   0.98976D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02
Stage-2 Tank Top, IMU Locat.     40015     0.17623D-07  -0.32828D-06  -0.47999D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.21151D-07  -0.61299D-05  -0.69013D-01  -0.21820D-06   0.14102D-02  -0.60904D-06
Fuel Slosh Mass Locat.             600     0.15784D-07   0.17489D-04   0.29102D-01  -0.20200D-06   0.45227D-02  -0.85109D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.10266D-06   0.17061D-04   0.62050D-01  -0.51830D-04   0.68070D-02   0.27982D-05

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    78.979       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.27746D-01   0.11006D+00  -0.72966D-02  -0.25224D-04  -0.73172D-03  -0.11216D-01
S1 Engine No:2 +Y-Z               1152     0.12983D-01   0.11003D+00  -0.72848D-02   0.46234D-05  -0.72280D-03  -0.11324D-01
S1 Engine No:3 -Y-Z               1153    -0.94413D-02   0.11003D+00  -0.73064D-02   0.96890D-06  -0.76706D-03  -0.11326D-01
S1 Engine No:4 -Y-Z               1154    -0.26305D-01   0.11006D+00  -0.72919D-02  -0.22799D-04  -0.77470D-03  -0.11219D-01
S1 Engine No:5 -Y+Z               1155    -0.27799D-01   0.11005D+00  -0.72934D-02   0.26978D-04  -0.73308D-03  -0.11218D-01
S1 Engine No:6 -Y+Z               1156    -0.13033D-01   0.11003D+00  -0.72850D-02  -0.79184D-05  -0.72091D-03  -0.11325D-01
S1 Engine No:7 +Y+Z               1157     0.93936D-02   0.11003D+00  -0.73106D-02  -0.22976D-05  -0.76885D-03  -0.11327D-01
S1 Engine No:8 +Y+Z               1158     0.26258D-01   0.11006D+00  -0.72955D-02   0.27463D-04  -0.77194D-03  -0.11220D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02  -0.64033D-06  -0.30289D-03  -0.45233D-02
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02  -0.64033D-06  -0.30289D-03  -0.45233D-02
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02  -0.64033D-06  -0.30289D-03  -0.45233D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02
Stage-2 Tank Top, IMU Locat.     40015     0.14411D-04   0.32256D-01  -0.21618D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.77610D-05  -0.15360D+00   0.10207D-01  -0.13663D-06   0.31579D-04   0.46290D-03
Fuel Slosh Mass Locat.             600    -0.23260D-04   0.35700D-01  -0.23562D-02   0.20230D-06  -0.72472D-03  -0.10909D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.72574D-03   0.12592D+00  -0.83679D-02   0.49966D-03  -0.15425D-02  -0.23041D-01

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    79.066       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.94138D-02   0.74901D-02   0.11120D+00   0.74812D-06   0.11343D-01  -0.77818D-03
S1 Engine No:2 +Y-Z               1152    -0.26317D-01   0.74770D-02   0.11123D+00  -0.22543D-04   0.11236D-01  -0.78445D-03
S1 Engine No:3 -Y-Z               1153    -0.27826D-01   0.74791D-02   0.11123D+00   0.23633D-04   0.11233D-01  -0.73878D-03
S1 Engine No:4 -Y-Z               1154    -0.13048D-01   0.74701D-02   0.11120D+00  -0.51535D-05   0.11340D-01  -0.72931D-03
S1 Engine No:5 -Y+Z               1155     0.94116D-02   0.74928D-02   0.11120D+00  -0.26544D-05   0.11344D-01  -0.77881D-03
S1 Engine No:6 -Y+Z               1156     0.26314D-01   0.74794D-02   0.11123D+00   0.25488D-04   0.11236D-01  -0.78245D-03
S1 Engine No:7 +Y+Z               1157     0.27821D-01   0.74809D-02   0.11123D+00  -0.25254D-04   0.11232D-01  -0.73943D-03
S1 Engine No:8 +Y+Z               1158     0.13045D-01   0.74699D-02   0.11120D+00   0.47081D-05   0.11341D-01  -0.72948D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01  -0.13656D-06   0.45017D-02  -0.29986D-03
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01  -0.13656D-06   0.45017D-02  -0.29986D-03
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01  -0.13656D-06   0.45017D-02  -0.29986D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01
Stage-2 Tank Top, IMU Locat.     40015     0.86736D-06   0.21628D-02   0.32496D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.53356D-06  -0.10300D-01  -0.15349D+00  -0.12330D-06  -0.43104D-03   0.28136D-04
Fuel Slosh Mass Locat.             600    -0.15318D-05   0.24815D-02   0.36746D-01  -0.11826D-06   0.10928D-01  -0.73355D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.45408D-04   0.84536D-02   0.12596D+00  -0.24703D-03   0.22286D-01  -0.14862D-02

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    107.97       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.68325D-06   0.45868D-02   0.11079D-01   0.46439D-02  -0.95764D-06   0.19456D-06
S1 Engine No:2 +Y-Z               1152     0.21528D-05   0.11080D-01   0.45855D-02   0.46439D-02  -0.10666D-05   0.73914D-07
S1 Engine No:3 -Y-Z               1153     0.22503D-05   0.11080D-01  -0.45969D-02   0.46439D-02  -0.80180D-06   0.75487D-07
S1 Engine No:4 -Y-Z               1154     0.10811D-05   0.45868D-02  -0.11090D-01   0.46439D-02  -0.93583D-06   0.18106D-06
S1 Engine No:5 -Y+Z               1155    -0.83379D-06  -0.45957D-02  -0.11090D-01   0.46439D-02  -0.94475D-06  -0.72433D-07
S1 Engine No:6 -Y+Z               1156    -0.22107D-05  -0.11089D-01  -0.45969D-02   0.46439D-02  -0.82543D-06   0.68502D-07
S1 Engine No:7 +Y+Z               1157    -0.24043D-05  -0.11089D-01   0.45855D-02   0.46439D-02  -0.10675D-05   0.67109D-07
S1 Engine No:8 +Y+Z               1158    -0.11429D-05  -0.45957D-02   0.11079D-01   0.46439D-02  -0.94398D-06  -0.59196D-07

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05   0.33598D-02  -0.12137D-05  -0.23036D-06
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05   0.33598D-02  -0.12137D-05  -0.23036D-06
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05   0.33598D-02  -0.12137D-05  -0.23036D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05
Stage-2 Tank Top, IMU Locat.     40015     0.43057D-07  -0.80947D-06   0.68444D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.84570D-08   0.11832D-05   0.94382D-05   0.39685D-02   0.44412D-06   0.17657D-06
Fuel Slosh Mass Locat.             600    -0.42386D-07  -0.39234D-05   0.53697D-06   0.45822D-02  -0.88120D-06   0.87716D-07

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.81939D-06   0.36618D-05  -0.12329D-04   0.53972D-02  -0.64873D-05  -0.63389D-05

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    118.66       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.18348D-01   0.39238D-01  -0.21351D-02  -0.13115D-04  -0.47166D-03  -0.76390D-02
S1 Engine No:2 +Y-Z               1152     0.83002D-02   0.39225D-01  -0.21342D-02   0.99830D-05  -0.47009D-03  -0.76729D-02
S1 Engine No:3 -Y-Z               1153    -0.68687D-02   0.39225D-01  -0.21618D-02   0.74214D-05  -0.44059D-03  -0.76726D-02
S1 Engine No:4 -Y-Z               1154    -0.18196D-01   0.39238D-01  -0.21591D-02  -0.10735D-04  -0.44640D-03  -0.76408D-02
S1 Engine No:5 -Y+Z               1155    -0.19108D-01   0.39218D-01  -0.21634D-02   0.28057D-04  -0.47503D-03  -0.76451D-02
S1 Engine No:6 -Y+Z               1156    -0.90564D-02   0.39189D-01  -0.21475D-02  -0.11081D-06  -0.47270D-03  -0.76764D-02
S1 Engine No:7 +Y+Z               1157     0.61149D-02   0.39189D-01  -0.21533D-02   0.43444D-05  -0.44686D-03  -0.76709D-02
S1 Engine No:8 +Y+Z               1158     0.17443D-01   0.39222D-01  -0.21314D-02   0.28730D-04  -0.44555D-03  -0.76368D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02  -0.41551D-05  -0.83762D-03  -0.13685D-01
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02  -0.41551D-05  -0.83762D-03  -0.13685D-01
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02  -0.41551D-05  -0.83762D-03  -0.13685D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02
Stage-2 Tank Top, IMU Locat.     40015     0.10586D-03  -0.25924D-01   0.15808D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.17902D-03  -0.61662D-01   0.36433D-02   0.24540D-05   0.30205D-03   0.48654D-02
Fuel Slosh Mass Locat.             600    -0.35770D-03  -0.11461D-01   0.88105D-03   0.64460D-05  -0.42097D-03  -0.70529D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.32358D-02   0.95378D-01  -0.59402D-02   0.20245D-02  -0.31440D-02  -0.47554D-01

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    119.29       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.69052D-02  -0.34408D-02  -0.51272D-01   0.60010D-06  -0.82111D-02   0.51200D-03
S1 Engine No:2 +Y-Z               1152     0.19072D-01  -0.34248D-02  -0.51300D-01   0.24426D-04  -0.81430D-02   0.51830D-03
S1 Engine No:3 -Y-Z               1153     0.20100D-01  -0.34294D-02  -0.51300D-01  -0.23006D-04  -0.81432D-02   0.52008D-03
S1 Engine No:4 -Y-Z               1154     0.93784D-02  -0.34220D-02  -0.51277D-01   0.69791D-05  -0.82112D-02   0.51467D-03
S1 Engine No:5 -Y+Z               1155    -0.68703D-02  -0.34470D-02  -0.51277D-01   0.44682D-05  -0.82123D-02   0.51296D-03
S1 Engine No:6 -Y+Z               1156    -0.19036D-01  -0.34344D-02  -0.51304D-01  -0.25339D-04  -0.81425D-02   0.51590D-03
S1 Engine No:7 +Y+Z               1157    -0.20061D-01  -0.34382D-02  -0.51301D-01   0.27720D-04  -0.81416D-02   0.52076D-03
S1 Engine No:8 +Y+Z               1158    -0.93421D-02  -0.34243D-02  -0.51272D-01  -0.35912D-05  -0.82114D-02   0.51468D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01  -0.14226D-05  -0.14072D-01   0.87086D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01  -0.14226D-05  -0.14072D-01   0.87086D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01  -0.14226D-05  -0.14072D-01   0.87086D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.21343D-05   0.15884D-02   0.25569D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.97389D-05   0.43022D-02   0.67358D-01   0.36378D-06   0.47519D-02  -0.28968D-03
Fuel Slosh Mass Locat.             600     0.17259D-04   0.99565D-05   0.31459D-02   0.14172D-05  -0.75980D-02   0.48110D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.12631D-03  -0.55260D-02  -0.91041D-01   0.78224D-03  -0.36744D-01   0.20340D-02

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    137.86       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13529D-01  -0.11918D+00   0.98327D-02   0.15640D-03   0.22816D-03   0.40548D-02
S1 Engine No:2 +Y-Z               1152    -0.76710D-02  -0.11901D+00   0.97015D-02   0.45341D-04   0.18445D-03   0.45671D-02
S1 Engine No:3 -Y-Z               1153     0.15562D-02  -0.11901D+00   0.96606D-02   0.60460D-04   0.50838D-03   0.45751D-02
S1 Engine No:4 -Y-Z               1154     0.84526D-02  -0.11918D+00   0.95180D-02   0.14839D-03   0.53612D-03   0.40436D-02
S1 Engine No:5 -Y+Z               1155     0.92151D-02  -0.11928D+00   0.95122D-02  -0.32608D-04   0.21646D-03   0.40236D-02
S1 Engine No:6 -Y+Z               1156     0.33468D-02  -0.11930D+00   0.95723D-02   0.95294D-04   0.14237D-03   0.45557D-02
S1 Engine No:7 +Y+Z               1157    -0.58881D-02  -0.11930D+00   0.98011D-02   0.73031D-04   0.47719D-03   0.45923D-02
S1 Engine No:8 +Y+Z               1158    -0.12784D-01  -0.11930D+00   0.98382D-02  -0.32995D-04   0.51137D-03   0.40818D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04  -0.25920D-04   0.34897D-03   0.42708D-02
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04  -0.25920D-04   0.34897D-03   0.42708D-02
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04  -0.25920D-04   0.34897D-03   0.42708D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04
Stage-2 Tank Top, IMU Locat.     40015     0.11334D-02   0.89689D-03  -0.72118D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.87747D-03   0.61775D-01  -0.50183D-02   0.29689D-04   0.11798D-03   0.14599D-02
Fuel Slosh Mass Locat.             600    -0.20277D-02  -0.86149D-01   0.69928D-02   0.61050D-04   0.38958D-03   0.47916D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.15021D-01   0.11283D+00  -0.91412D-02   0.92557D-02  -0.12686D-01  -0.15650D+00

MODE# 11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    150.07       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.18421D-02  -0.89909D-02  -0.10980D+00  -0.67746D-04  -0.26788D-02   0.37357D-03
S1 Engine No:2 +Y-Z               1152     0.58836D-02  -0.90290D-02  -0.10979D+00   0.25656D-04  -0.20789D-02   0.40954D-03
S1 Engine No:3 -Y-Z               1153     0.63322D-02  -0.90233D-02  -0.10965D+00  -0.15786D-03  -0.20477D-02   0.24672D-04
S1 Engine No:4 -Y-Z               1154     0.28938D-02  -0.88994D-02  -0.10949D+00  -0.40620D-04  -0.26495D-02  -0.41018D-04
S1 Engine No:5 -Y+Z               1155    -0.26064D-02  -0.88733D-02  -0.10949D+00  -0.54034D-04  -0.26855D-02   0.36800D-03
S1 Engine No:6 -Y+Z               1156    -0.66456D-02  -0.87319D-02  -0.10967D+00  -0.16276D-03  -0.20856D-02   0.39970D-03
S1 Engine No:7 +Y+Z               1157    -0.70879D-02  -0.87246D-02  -0.10979D+00   0.35203D-04  -0.20519D-02   0.29994D-04
S1 Engine No:8 +Y+Z               1158    -0.36547D-02  -0.87725D-02  -0.10979D+00  -0.85367D-04  -0.26536D-02  -0.32824D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02   0.21368D-04  -0.30372D-02   0.24540D-03
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02   0.21368D-04  -0.30372D-02   0.24540D-03
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02   0.21368D-04  -0.30372D-02   0.24540D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02
Stage-2 Tank Top, IMU Locat.     40015     0.15916D-03  -0.17212D-03  -0.21345D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.17614D-03   0.45243D-02   0.55883D-01  -0.32063D-04  -0.24332D-02   0.19708D-03
Fuel Slosh Mass Locat.             600    -0.35769D-03  -0.71723D-02  -0.88581D-01  -0.60629D-04  -0.31170D-02   0.25234D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.17496D-02   0.14253D-01   0.17558D+00  -0.62749D-02   0.19573D+00  -0.15899D-01

MODE# 12/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    182.92       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.16052D-04  -0.91728D-01  -0.22101D+00  -0.92639D-01  -0.54512D-05  -0.15880D-04
S1 Engine No:2 +Y-Z               1152     0.12143D-04  -0.22127D+00  -0.91472D-01  -0.92640D-01  -0.53810D-08  -0.64922D-05
S1 Engine No:3 -Y-Z               1153     0.40023D-05  -0.22127D+00   0.91728D-01  -0.92640D-01  -0.14092D-04  -0.56674D-05
S1 Engine No:4 -Y-Z               1154    -0.14758D-04  -0.91729D-01   0.22127D+00  -0.92640D-01  -0.51679D-05  -0.14171D-04
S1 Engine No:5 -Y+Z               1155    -0.22150D-04   0.91471D-01   0.22127D+00  -0.92640D-01  -0.62069D-05  -0.25580D-06
S1 Engine No:6 -Y+Z               1156    -0.24044D-04   0.22101D+00   0.91728D-01  -0.92640D-01  -0.14453D-04  -0.63692D-05
S1 Engine No:7 +Y+Z               1157    -0.99118D-05   0.22101D+00  -0.91471D-01  -0.92640D-01   0.14650D-05  -0.51780D-05
S1 Engine No:8 +Y+Z               1158     0.30811D-05   0.91470D-01  -0.22101D+00  -0.92640D-01  -0.48935D-05   0.21400D-06

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04   0.21989D-01   0.48624D-05   0.51151D-05
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04   0.21989D-01   0.48624D-05   0.51151D-05
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04   0.21989D-01   0.48624D-05   0.51151D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04
Stage-2 Tank Top, IMU Locat.     40015     0.12545D-05  -0.19478D-04   0.18468D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.27777D-05   0.10758D-03  -0.10305D-03  -0.54974D-01   0.99894D-05   0.10399D-04
Fuel Slosh Mass Locat.             600    -0.45818D-05  -0.16024D-03   0.15608D-03  -0.89100D-01  -0.32438D-05  -0.36702D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.45574D-05   0.50733D-03  -0.45925D-03  -0.15652D+00  -0.34514D-03  -0.38507D-03

MODE# 13/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    209.92       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.37565D-01   0.10180D+00  -0.49475D-02  -0.11924D-03  -0.82676D-03  -0.15372D-01
S1 Engine No:2 +Y-Z               1152     0.16762D-01   0.10170D+00  -0.49477D-02   0.11067D-03  -0.79661D-03  -0.15894D-01
S1 Engine No:3 -Y-Z               1153    -0.14762D-01   0.10170D+00  -0.52552D-02   0.87816D-04  -0.74238D-03  -0.15904D-01
S1 Engine No:4 -Y-Z               1154    -0.37818D-01   0.10180D+00  -0.52423D-02  -0.96025D-04  -0.80498D-03  -0.15400D-01
S1 Engine No:5 -Y+Z               1155    -0.39473D-01   0.10159D+00  -0.52590D-02   0.28019D-03  -0.85631D-03  -0.15422D-01
S1 Engine No:6 -Y+Z               1156    -0.18638D-01   0.10131D+00  -0.50904D-02  -0.25153D-06  -0.81479D-03  -0.15925D-01
S1 Engine No:7 +Y+Z               1157     0.12912D-01   0.10131D+00  -0.51582D-02   0.41830D-04  -0.79108D-03  -0.15894D-01
S1 Engine No:8 +Y+Z               1158     0.35966D-01   0.10163D+00  -0.49362D-02   0.28580D-03  -0.79262D-03  -0.15368D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02  -0.14657D-04   0.25667D-03   0.50778D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02  -0.14657D-04   0.25667D-03   0.50778D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02  -0.14657D-04   0.25667D-03   0.50778D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.48052D-03  -0.44564D-01   0.22501D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.75031D-03   0.48246D-01  -0.25503D-02   0.48919D-04   0.70139D-03   0.13651D-01
Fuel Slosh Mass Locat.             600    -0.89617D-03  -0.70780D-02   0.46299D-03   0.71485D-04  -0.69130D-03  -0.13496D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.24129D-02   0.57956D-01  -0.34540D-02  -0.28346D-02   0.16589D-03   0.11206D-01

MODE# 14/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    210.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13992D-01   0.54396D-02   0.10515D+00  -0.40729D-04   0.15928D-01  -0.77290D-03
S1 Engine No:2 +Y-Z               1152    -0.37103D-01   0.52562D-02   0.10542D+00  -0.22928D-03   0.15391D-01  -0.81394D-03
S1 Engine No:3 -Y-Z               1153    -0.38706D-01   0.52765D-02   0.10551D+00   0.12538D-03   0.15394D-01  -0.79847D-03
S1 Engine No:4 -Y-Z               1154    -0.17807D-01   0.52816D-02   0.10541D+00  -0.10529D-03   0.15931D-01  -0.77063D-03
S1 Engine No:5 -Y+Z               1155     0.13803D-01   0.55829D-02   0.10541D+00  -0.90948D-04   0.15936D-01  -0.78089D-03
S1 Engine No:6 -Y+Z               1156     0.36905D-01   0.55551D-02   0.10553D+00   0.14310D-03   0.15384D-01  -0.79612D-03
S1 Engine No:7 +Y+Z               1157     0.38488D-01   0.55695D-02   0.10542D+00  -0.25367D-03   0.15379D-01  -0.80168D-03
S1 Engine No:8 +Y+Z               1158     0.17605D-01   0.53927D-02   0.10515D+00  -0.17734D-04   0.15929D-01  -0.76897D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01   0.11448D-04  -0.49738D-02   0.25447D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01   0.11448D-04  -0.49738D-02   0.25447D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01   0.11448D-04  -0.49738D-02   0.25447D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.13742D-04  -0.22744D-02  -0.44406D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.72383D-04   0.22939D-02   0.47055D-01  -0.38850D-04  -0.13622D-01   0.68531D-03
Fuel Slosh Mass Locat.             600    -0.95712D-04  -0.91577D-04  -0.38421D-02  -0.56622D-04   0.13554D-01  -0.68404D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.18073D-03   0.16051D-02   0.41788D-01   0.22675D-02  -0.24989D-01   0.16878D-02

MODE# 15/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    257.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.25877D-01   0.69907D-01  -0.83851D-03  -0.17416D-03  -0.19752D-03  -0.10471D-01
S1 Engine No:2 +Y-Z               1152     0.11014D-01   0.69746D-01  -0.77930D-03   0.93919D-04  -0.19502D-03  -0.11055D-01
S1 Engine No:3 -Y-Z               1153    -0.10934D-01   0.69747D-01  -0.10853D-02   0.82055D-04  -0.86784D-04  -0.11056D-01
S1 Engine No:4 -Y-Z               1154    -0.26242D-01   0.69899D-01  -0.10274D-02  -0.14755D-03  -0.13976D-03  -0.10481D-01
S1 Engine No:5 -Y+Z               1155    -0.26613D-01   0.69721D-01  -0.10374D-02   0.29702D-03  -0.22422D-03  -0.10510D-01
S1 Engine No:6 -Y+Z               1156    -0.11711D-01   0.69445D-01  -0.87672D-03  -0.36472D-04  -0.19390D-03  -0.11085D-01
S1 Engine No:7 +Y+Z               1157     0.10274D-01   0.69449D-01  -0.10442D-02  -0.11828D-06  -0.12000D-03  -0.11057D-01
S1 Engine No:8 +Y+Z               1158     0.25577D-01   0.69767D-01  -0.83418D-03   0.30698D-03  -0.11182D-03  -0.10467D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03  -0.91014D-05  -0.13655D-04  -0.91117D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03  -0.91014D-05  -0.13655D-04  -0.91117D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03  -0.91014D-05  -0.13655D-04  -0.91117D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.22802D-02   0.46787D-01  -0.71329D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.39782D-03   0.13042D+00  -0.19625D-02   0.42964D-04   0.27811D-04   0.21389D-02
Fuel Slosh Mass Locat.             600    -0.33691D-03  -0.66160D-02   0.16968D-03   0.51712D-04  -0.12064D-03  -0.82895D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.22559D-02   0.45418D-01  -0.12007D-02  -0.43914D-02  -0.38921D-03   0.22921D-02

MODE# 16/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    258.09       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.10514D-01   0.11942D-02   0.70526D-01  -0.79446D-05   0.10964D-01  -0.12767D-03
S1 Engine No:2 +Y-Z               1152    -0.25743D-01   0.10242D-02   0.70791D-01  -0.23970D-03   0.10386D-01  -0.15588D-03
S1 Engine No:3 -Y-Z               1153    -0.26084D-01   0.10390D-02   0.70852D-01   0.16788D-03   0.10389D-01  -0.18410D-03
S1 Engine No:4 -Y-Z               1154    -0.11304D-01   0.10016D-02   0.70712D-01  -0.98070D-04   0.10970D-01  -0.17917D-03
S1 Engine No:5 -Y+Z               1155     0.10494D-01   0.13185D-02   0.70712D-01  -0.95620D-04   0.10976D-01  -0.13160D-03
S1 Engine No:6 -Y+Z               1156     0.25709D-01   0.12570D-02   0.70878D-01   0.19242D-03   0.10380D-01  -0.13168D-03
S1 Engine No:7 +Y+Z               1157     0.26024D-01   0.12649D-02   0.70811D-01  -0.26567D-03   0.10376D-01  -0.18810D-03
S1 Engine No:8 +Y+Z               1158     0.11265D-01   0.10825D-02   0.70526D-01  -0.64356D-06   0.10966D-01  -0.18121D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01   0.77614D-05   0.87654D-03  -0.12966D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01   0.77614D-05   0.87654D-03  -0.12966D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01   0.77614D-05   0.87654D-03  -0.12966D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.29560D-04   0.68352D-03   0.47052D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.16618D-04   0.19241D-02   0.13073D+00  -0.35380D-04  -0.19566D-02   0.33079D-04
Fuel Slosh Mass Locat.             600    -0.18065D-04  -0.72520D-05  -0.52174D-02  -0.42428D-04   0.82223D-02  -0.12499D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.83825D-04   0.29138D-04   0.37263D-01   0.35836D-02  -0.86971D-02   0.55522D-03

MODE# 17/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    281.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.85768D-04  -0.10242D-01  -0.28368D-01  -0.11494D-01   0.91660D-05   0.34948D-04
S1 Engine No:2 +Y-Z               1152     0.91213D-04  -0.26312D-01  -0.12300D-01  -0.11484D-01   0.31951D-04   0.12148D-04
S1 Engine No:3 -Y-Z               1153     0.96725D-04  -0.26312D-01   0.10420D-01  -0.11491D-01   0.10936D-04   0.21348D-05
S1 Engine No:4 -Y-Z               1154     0.11096D-03  -0.10238D-01   0.26494D-01  -0.11492D-01  -0.68780D-05   0.28392D-04
S1 Engine No:5 -Y+Z               1155     0.10848D-03   0.12481D-01   0.26494D-01  -0.11482D-01   0.11606D-04   0.46469D-04
S1 Engine No:6 -Y+Z               1156     0.10177D-03   0.28547D-01   0.10425D-01  -0.11494D-01   0.34576D-04   0.14464D-04
S1 Engine No:7 +Y+Z               1157     0.99383D-04   0.28548D-01  -0.12306D-01  -0.11486D-01   0.22681D-04  -0.96511D-06
S1 Engine No:8 +Y+Z               1158     0.82699D-04   0.12486D-01  -0.28368D-01  -0.11484D-01  -0.31730D-05   0.26104D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04   0.19912D-02  -0.21992D-06  -0.32531D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04   0.19912D-02  -0.21992D-06  -0.32531D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04   0.19912D-02  -0.21992D-06  -0.32531D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.20305D-04   0.64281D-04  -0.54978D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.85847D-04   0.30647D-03  -0.25758D-03  -0.10659D-01   0.52621D-06   0.92196D-06
Fuel Slosh Mass Locat.             600     0.91694D-04   0.99256D-03  -0.81637D-03  -0.11367D-01  -0.48326D-05  -0.34667D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.49319D-03  -0.59041D-02   0.43504D-02   0.11662D+01   0.24125D-02   0.36655D-02

MODE# 18/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.50       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.19418D-01  -0.44199D-01   0.15771D-02   0.29689D-03   0.54901D-03   0.77059D-02
S1 Engine No:2 +Y-Z               1152    -0.89818D-02  -0.43893D-01   0.13880D-02  -0.51404D-04   0.56854D-03   0.82600D-02
S1 Engine No:3 -Y-Z               1153     0.73434D-02  -0.43893D-01   0.16264D-02  -0.27449D-04   0.20312D-03   0.82337D-02
S1 Engine No:4 -Y-Z               1154     0.18868D-01  -0.44186D-01   0.14339D-02   0.25286D-03   0.28566D-03   0.76802D-02
S1 Engine No:5 -Y+Z               1155     0.19735D-01  -0.44093D-01   0.14340D-02  -0.30245D-03   0.58409D-03   0.77443D-02
S1 Engine No:6 -Y+Z               1156     0.92410D-02  -0.43870D-01   0.13482D-02   0.15655D-03   0.55103D-03   0.83056D-02
S1 Engine No:7 +Y+Z               1157    -0.71565D-02  -0.43875D-01   0.17582D-02   0.88409D-04   0.22398D-03   0.82489D-02
S1 Engine No:8 +Y+Z               1158    -0.18662D-01  -0.44172D-01   0.15849D-02  -0.31460D-03   0.23150D-03   0.76738D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04  -0.23396D-05  -0.59456D-06  -0.36424D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04  -0.23396D-05  -0.59456D-06  -0.36424D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04  -0.23396D-05  -0.59456D-06  -0.36424D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.67115D-03   0.21324D-01  -0.32586D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.35340D-03   0.50211D-02  -0.48013D-03   0.15089D-04  -0.39366D-04   0.92808D-02
Fuel Slosh Mass Locat.             600     0.13723D-03   0.74193D-02  -0.99640D-03   0.12474D-04   0.28643D-03   0.51522D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.23113D-02  -0.29949D-01   0.11421D-02  -0.16452D-02   0.25439D-03   0.19286D-02

MODE# 19/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.67       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.52406D-01  -0.66960D-01   0.18037D-01   0.49411D-03   0.53318D-02   0.21084D-01
S1 Engine No:2 +Y-Z               1152    -0.30567D-01  -0.66472D-01   0.17803D-01  -0.15880D-03   0.53184D-02   0.21066D-01
S1 Engine No:3 -Y-Z               1153     0.10409D-01  -0.66465D-01   0.18119D-01   0.56450D-04   0.36475D-02   0.20824D-01
S1 Engine No:4 -Y-Z               1154     0.44615D-01  -0.67020D-01   0.17704D-01   0.36067D-03   0.39181D-02   0.20834D-01
S1 Engine No:5 -Y+Z               1155     0.53813D-01  -0.66745D-01   0.17748D-01  -0.50800D-03   0.54198D-02   0.21192D-01
S1 Engine No:6 -Y+Z               1156     0.31857D-01  -0.66425D-01   0.17727D-01   0.38114D-03   0.53185D-02   0.21181D-01
S1 Engine No:7 +Y+Z               1157    -0.92688D-02  -0.66430D-01   0.18397D-01   0.57359D-04   0.37158D-02   0.20834D-01
S1 Engine No:8 +Y+Z               1158    -0.43427D-01  -0.66999D-01   0.18010D-01  -0.48152D-03   0.38287D-02   0.20783D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03  -0.47956D-05  -0.10629D-04   0.33070D-03
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03  -0.47956D-05  -0.10629D-04   0.33070D-03
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03  -0.47956D-05  -0.10629D-04   0.33070D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03
Stage-2 Tank Top, IMU Locat.     40015     0.48837D-03  -0.19947D-01  -0.70481D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.48719D-03   0.29826D-01  -0.54718D-02   0.30913D-04  -0.29833D-03  -0.12546D-01
Fuel Slosh Mass Locat.             600     0.57954D-03   0.64273D-01  -0.10875D-01   0.25501D-04   0.32647D-02   0.15622D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.33864D-02  -0.39595D-01   0.96782D-02  -0.33803D-02   0.20075D-03   0.67987D-02

MODE# 20/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.70       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.77011D-02  -0.16803D-01  -0.76746D-01  -0.12925D-04  -0.19442D-01   0.44293D-02
S1 Engine No:2 +Y-Z               1152     0.40779D-01  -0.16459D-01  -0.77245D-01   0.37704D-03  -0.19062D-01   0.45358D-02
S1 Engine No:3 -Y-Z               1153     0.50713D-01  -0.16501D-01  -0.77064D-01  -0.48589D-03  -0.19463D-01   0.56056D-02
S1 Engine No:4 -Y-Z               1154     0.31155D-01  -0.16373D-01  -0.76669D-01   0.23030D-03  -0.19801D-01   0.56558D-02
S1 Engine No:5 -Y+Z               1155    -0.74105D-02  -0.16848D-01  -0.76659D-01   0.15943D-04  -0.19456D-01   0.44546D-02
S1 Engine No:6 -Y+Z               1156    -0.40462D-01  -0.16445D-01  -0.77237D-01  -0.48055D-03  -0.19042D-01   0.44879D-02
S1 Engine No:7 +Y+Z               1157    -0.50344D-01  -0.16470D-01  -0.77179D-01   0.49982D-03  -0.19410D-01   0.56134D-02
S1 Engine No:8 +Y+Z               1158    -0.30844D-01  -0.16317D-01  -0.76754D-01  -0.23945D-03  -0.19796D-01   0.56562D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02   0.24011D-05   0.48926D-04   0.70044D-04
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02   0.24011D-05   0.48926D-04   0.70044D-04
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02   0.24011D-05   0.48926D-04   0.70044D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02
Stage-2 Tank Top, IMU Locat.     40015     0.98335D-04  -0.42322D-02   0.33144D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.13376D-03   0.70693D-02   0.23295D-01  -0.15203D-04   0.11290D-02  -0.27442D-02
Fuel Slosh Mass Locat.             600     0.14921D-03   0.15090D-01   0.45895D-01  -0.12494D-04  -0.13901D-01   0.37502D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.92427D-03  -0.91239D-02  -0.38518D-01   0.17035D-02   0.13382D-02   0.10759D-02

MODE# 21/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    318.90       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11063D-01   0.28406D-03   0.25618D-01   0.46805D-04   0.11500D-01   0.47736D-03
S1 Engine No:2 +Y-Z               1152    -0.26601D-01   0.20584D-03   0.25783D-01  -0.13123D-03   0.11886D-01   0.41838D-03
S1 Engine No:3 -Y-Z               1153    -0.26726D-01   0.24622D-03   0.25740D-01   0.16610D-03   0.11892D-01  -0.54226D-03
S1 Engine No:4 -Y-Z               1154    -0.11335D-01   0.15533D-03   0.25554D-01  -0.52961D-04   0.11514D-01  -0.58320D-03
S1 Engine No:5 -Y+Z               1155     0.11079D-01   0.32540D-03   0.25554D-01  -0.49945D-04   0.11515D-01   0.47750D-03
S1 Engine No:6 -Y+Z               1156     0.26594D-01   0.20613D-03   0.25773D-01   0.19622D-03   0.11878D-01   0.44992D-03
S1 Engine No:7 +Y+Z               1157     0.26683D-01   0.23849D-03   0.25816D-01  -0.16124D-03   0.11877D-01  -0.54430D-03
S1 Engine No:8 +Y+Z               1158     0.11320D-01   0.13440D-03   0.25618D-01   0.43765D-04   0.11503D-01  -0.58837D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01  -0.79754D-06   0.39857D-03  -0.37765D-06
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01  -0.79754D-06   0.39857D-03  -0.37765D-06
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01  -0.79754D-06   0.39857D-03  -0.37765D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01
Stage-2 Tank Top, IMU Locat.     40015     0.51711D-06   0.21259D-04   0.31610D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.64053D-05  -0.73563D-04  -0.17849D-01   0.84264D-05  -0.15960D-01   0.17824D-04
Fuel Slosh Mass Locat.             600    -0.56533D-05  -0.12577D-03  -0.46450D-01   0.73787D-05   0.92096D-02  -0.40189D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.43517D-04  -0.15518D-03   0.87845D-02  -0.93102D-03   0.13625D-02   0.19303D-03

MODE# 22/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    341.52       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.86066D-05  -0.10564D-01  -0.25587D-01  -0.10706D-01  -0.82428D-06  -0.47254D-05
S1 Engine No:2 +Y-Z               1152     0.59595D-05  -0.25541D-01  -0.10611D-01  -0.10706D-01   0.30095D-05  -0.14628D-05
S1 Engine No:3 -Y-Z               1153     0.42740D-05  -0.25541D-01   0.10571D-01  -0.10707D-01  -0.43883D-05  -0.16403D-05
S1 Engine No:4 -Y-Z               1154    -0.95927D-06  -0.10564D-01   0.25548D-01  -0.10706D-01  -0.12863D-05  -0.42974D-05
S1 Engine No:5 -Y+Z               1155    -0.17178D-05   0.10617D-01   0.25548D-01  -0.10706D-01  -0.88348D-06   0.28813D-05
S1 Engine No:6 -Y+Z               1156    -0.22763D-05   0.25594D-01   0.10571D-01  -0.10707D-01  -0.33928D-05  -0.16708D-05
S1 Engine No:7 +Y+Z               1157     0.30175D-05   0.25594D-01  -0.10611D-01  -0.10706D-01   0.32485D-05  -0.18403D-05
S1 Engine No:8 +Y+Z               1158     0.48784D-05   0.10618D-01  -0.25587D-01  -0.10706D-01  -0.11764D-05   0.21202D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06   0.40140D-02  -0.10083D-06  -0.78434D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06   0.40140D-02  -0.10083D-06  -0.78434D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06   0.40140D-02  -0.10083D-06  -0.78434D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.61276D-06   0.38822D-06   0.97071D-06

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.34689D-05  -0.72700D-05   0.60520D-05   0.23153D-02   0.15628D-06   0.65449D-06
Fuel Slosh Mass Locat.             600     0.24756D-05   0.12036D-04  -0.10458D-04  -0.93350D-02  -0.79399D-06  -0.13348D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.24941D-04  -0.15170D-03   0.10516D-03   0.19988D-01   0.53065D-04   0.89053D-04

MODE# 23/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    385.45       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.37289D-01  -0.35367D-01   0.19291D-03   0.78814D-03   0.13535D-02   0.16802D-01
S1 Engine No:2 +Y-Z               1152    -0.16320D-01  -0.34451D-01  -0.46307D-03  -0.11896D-03   0.15799D-02   0.16700D-01
S1 Engine No:3 -Y-Z               1153     0.15875D-01  -0.34444D-01   0.20451D-03  -0.15724D-03  -0.15463D-02   0.16684D-01
S1 Engine No:4 -Y-Z               1154     0.37004D-01  -0.35159D-01  -0.28076D-03   0.57370D-03  -0.11608D-02   0.16774D-01
S1 Engine No:5 -Y+Z               1155     0.37417D-01  -0.34616D-01  -0.30711D-03  -0.97036D-03   0.15294D-02   0.16920D-01
S1 Engine No:6 -Y+Z               1156     0.16144D-01  -0.33951D-01  -0.58522D-03   0.63092D-03   0.14497D-02   0.16998D-01
S1 Engine No:7 +Y+Z               1157    -0.16589D-01  -0.33984D-01   0.91431D-03   0.36482D-03  -0.16186D-02   0.16858D-01
S1 Engine No:8 +Y+Z               1158    -0.37500D-01  -0.35000D-01   0.26185D-03  -0.10916D-02  -0.15208D-02   0.16759D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04  -0.10839D-05  -0.24758D-05  -0.50692D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04  -0.10839D-05  -0.24758D-05  -0.50692D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04  -0.10839D-05  -0.24758D-05  -0.50692D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.75169D-03  -0.62454D-01   0.28528D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.93195D-03  -0.56183D-01   0.36713D-04   0.56236D-05  -0.38612D-05  -0.85740D-02
Fuel Slosh Mass Locat.             600    -0.29381D-04   0.64561D-01  -0.51166D-04   0.25369D-05   0.57498D-05   0.11245D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.48923D-02  -0.17456D-01   0.37384D-03  -0.50195D-03   0.26696D-03   0.79482D-02

MODE# 24/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    387.43       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.16111D-01  -0.30189D-03  -0.34855D-01  -0.27095D-03  -0.16802D-01  -0.14693D-02
S1 Engine No:2 +Y-Z               1152     0.37456D-01   0.69413D-04  -0.35488D-01   0.62360D-03  -0.16964D-01  -0.12427D-02
S1 Engine No:3 -Y-Z               1153     0.37606D-01   0.76465D-04  -0.35284D-01  -0.78582D-03  -0.16972D-01   0.13732D-02
S1 Engine No:4 -Y-Z               1154     0.16283D-01   0.42063D-03  -0.34620D-01   0.42394D-03  -0.16910D-01   0.14898D-02
S1 Engine No:5 -Y+Z               1155    -0.16356D-01  -0.77114D-03  -0.34633D-01   0.32449D-03  -0.16874D-01  -0.15361D-02
S1 Engine No:6 -Y+Z               1156    -0.37470D-01  -0.18744D-03  -0.35551D-01  -0.96925D-03  -0.16891D-01  -0.14573D-02
S1 Engine No:7 +Y+Z               1157    -0.37337D-01  -0.13383D-03  -0.35768D-01   0.79919D-03  -0.16868D-01   0.13446D-02
S1 Engine No:8 +Y+Z               1158    -0.16261D-01   0.49210D-03  -0.34871D-01  -0.14869D-03  -0.16750D-01   0.15562D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01   0.16789D-05   0.51186D-02  -0.25808D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01   0.16789D-05   0.51186D-02  -0.25808D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01   0.16789D-05   0.51186D-02  -0.25808D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.18805D-05  -0.32778D-04  -0.61091D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10542D-04  -0.19048D-04  -0.56634D-01  -0.44063D-05   0.82526D-02  -0.44597D-05
Fuel Slosh Mass Locat.             600     0.42673D-05   0.12661D-04   0.64401D-01  -0.11106D-05  -0.11242D-01   0.53204D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.72853D-04   0.36528D-03  -0.11866D-01   0.36482D-03  -0.39662D-02  -0.26580D-03

MODE# 25/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    427.91       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.94065D-01   0.85144D-01   0.27368D-02  -0.15305D-01  -0.14185D-01  -0.36198D-01
S1 Engine No:2 +Y-Z               1152     0.51317D-01   0.73796D-01   0.98886D-02   0.81127D-02  -0.14246D-01  -0.54638D-01
S1 Engine No:3 -Y-Z               1153    -0.52048D-01   0.74109D-01  -0.12660D-01   0.54464D-02   0.15820D-01  -0.52916D-01
S1 Engine No:4 -Y-Z               1154    -0.92090D-01   0.87818D-01  -0.26777D-02  -0.15108D-01   0.12560D-01  -0.34145D-01
S1 Engine No:5 -Y+Z               1155    -0.92419D-01   0.88585D-01   0.19558D-03   0.14024D-01  -0.13097D-01  -0.35850D-01
S1 Engine No:6 -Y+Z               1156    -0.50638D-01   0.76569D-01   0.87114D-02  -0.55238D-02  -0.14398D-01  -0.52811D-01
S1 Engine No:7 +Y+Z               1157     0.49344D-01   0.76708D-01  -0.90429D-02  -0.42199D-02   0.15072D-01  -0.51713D-01
S1 Engine No:8 +Y+Z               1158     0.90666D-01   0.88820D-01   0.21616D-04   0.12574D-01   0.10861D-01  -0.34501D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03   0.28214D-05  -0.11404D-04  -0.23303D-02
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03   0.28214D-05  -0.11404D-04  -0.23303D-02
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03   0.28214D-05  -0.11404D-04  -0.23303D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03
Stage-2 Tank Top, IMU Locat.     40015     0.36669D-03  -0.35597D-01   0.17211D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.30007D-02   0.14085D+00  -0.67336D-03  -0.12913D-04   0.11125D-04   0.23538D-02
Fuel Slosh Mass Locat.             600    -0.51250D-03  -0.16306D+00   0.78645D-03  -0.66830D-06  -0.12289D-03  -0.25940D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.18199D-01   0.37763D-01  -0.99220D-03   0.79337D-03  -0.67102D-03  -0.23131D-01

MODE# 26/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    428.10       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.49930D-01  -0.10465D-01  -0.76609D-01  -0.53196D-02  -0.52088D-01  -0.13694D-01
S1 Engine No:2 +Y-Z               1152     0.92722D-01  -0.22409D-02  -0.88249D-01   0.13454D-01  -0.36103D-01  -0.11859D-01
S1 Engine No:3 -Y-Z               1153     0.92433D-01   0.27850D-03  -0.89216D-01  -0.12640D-01  -0.36083D-01   0.11646D-01
S1 Engine No:4 -Y-Z               1154     0.50176D-01   0.86423D-02  -0.77731D-01   0.44864D-02  -0.51473D-01   0.14070D-01
S1 Engine No:5 -Y+Z               1155    -0.48777D-01  -0.84834D-02  -0.77639D-01   0.51893D-02  -0.51824D-01  -0.13243D-01
S1 Engine No:6 -Y+Z               1156    -0.92524D-01  -0.10915D-02  -0.88203D-01  -0.12229D-01  -0.36371D-01  -0.11092D-01
S1 Engine No:7 +Y+Z               1157    -0.93545D-01   0.13210D-02  -0.87278D-01   0.13021D-01  -0.36398D-01   0.12070D-01
S1 Engine No:8 +Y+Z               1158    -0.50392D-01   0.86132D-02  -0.76531D-01  -0.59501D-02  -0.52439D-01   0.13783D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01   0.17946D-05  -0.23746D-02   0.10912D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01   0.17946D-05  -0.23746D-02   0.10912D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01   0.17946D-05  -0.23746D-02   0.10912D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.86645D-05   0.16631D-03   0.35775D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.61300D-04  -0.66063D-03  -0.14060D+00  -0.86507D-05   0.23683D-02  -0.11245D-04
Fuel Slosh Mass Locat.             600     0.91848D-05   0.75531D-03   0.16225D+00  -0.57930D-06  -0.25951D-01   0.12306D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.35424D-03   0.71866D-03  -0.22391D-01   0.55042D-03  -0.12143D-01  -0.51437D-03

MODE# 27/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    463.99       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.39562D-02  -0.20086D-01  -0.46074D-03   0.43067D-02   0.23509D-02  -0.71135D-02
S1 Engine No:2 +Y-Z               1152    -0.33728D-02  -0.16573D-01  -0.29846D-02  -0.17648D-02   0.31765D-02   0.11350D-02
S1 Engine No:3 -Y-Z               1153    -0.88509D-03  -0.16565D-01   0.31303D-02  -0.17609D-02  -0.27770D-02   0.95191D-03
S1 Engine No:4 -Y-Z               1154    -0.82335D-02  -0.20083D-01   0.58910D-03   0.43217D-02  -0.21982D-02  -0.75042D-02
S1 Engine No:5 -Y+Z               1155    -0.82975D-02  -0.20138D-01  -0.40010D-03  -0.42739D-02   0.21298D-02  -0.75260D-02
S1 Engine No:6 -Y+Z               1156    -0.94981D-03  -0.16610D-01  -0.29731D-02   0.16798D-02   0.27599D-02   0.88366D-03
S1 Engine No:7 +Y+Z               1157    -0.33510D-02  -0.16610D-01   0.30145D-02   0.17509D-02  -0.31523D-02   0.11242D-02
S1 Engine No:8 +Y+Z               1158     0.39471D-02  -0.20096D-01   0.51128D-03  -0.42881D-02  -0.23654D-02  -0.70708D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05  -0.17210D-05  -0.85244D-05  -0.29124D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05  -0.17210D-05  -0.85244D-05  -0.29124D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05  -0.17210D-05  -0.85244D-05  -0.29124D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.10136D-02  -0.15114D-02   0.45507D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.69369D-02   0.22441D-01  -0.67308D-04   0.59514D-05   0.16165D-04   0.53899D-02
Fuel Slosh Mass Locat.             600    -0.82029D-03  -0.41280D-01   0.12481D-03  -0.25459D-05  -0.11984D-04  -0.39619D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.22179D-01  -0.23163D-01   0.14410D-03  -0.13526D-03   0.66114D-04   0.55414D-02

MODE# 28/ 38, Frequency (rad/sec), Damping (zeta), Generalized Mass=    464.01       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13621D-02   0.32281D-02   0.17131D-01   0.17755D-02   0.11561D-02   0.31247D-02
S1 Engine No:2 +Y-Z               1152     0.61396D-02   0.56826D-03   0.20799D-01  -0.44543D-02  -0.74575D-02   0.23510D-02
S1 Engine No:3 -Y-Z               1153     0.61320D-02  -0.44667D-03   0.20789D-01   0.44524D-02  -0.74231D-02  -0.23581D-02
S1 Engine No:4 -Y-Z               1154    -0.13049D-02  -0.30718D-02   0.17153D-01  -0.17990D-02   0.11646D-02  -0.30641D-02
S1 Engine No:5 -Y+Z               1155     0.14151D-02   0.31765D-02   0.17154D-01  -0.17884D-02   0.11624D-02   0.31129D-02
S1 Engine No:6 -Y+Z               1156    -0.60547D-02   0.54704D-03   0.20790D-01   0.44321D-02  -0.74407D-02   0.23434D-02
S1 Engine No:7 +Y+Z               1157    -0.60206D-02  -0.46671D-03   0.20741D-01  -0.44675D-02  -0.74096D-02  -0.23764D-02
S1 Engine No:8 +Y+Z               1158     0.13905D-02  -0.30623D-02   0.17123D-01   0.18450D-02   0.12013D-02  -0.30613D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02  -0.20812D-06  -0.28530D-02   0.86874D-05
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02  -0.20812D-06  -0.28530D-02   0.86874D-05
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02  -0.20812D-06  -0.28530D-02   0.86874D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02
Stage-2 Tank Top, IMU Locat.     40015     0.19861D-04   0.44427D-05   0.14891D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.13110D-03  -0.67090D-04  -0.22468D-01   0.11179D-05   0.53812D-02  -0.16124D-04
Fuel Slosh Mass Locat.             600     0.16448D-04   0.12406D-03   0.41612D-01  -0.24356D-06  -0.39563D-02   0.11744D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.40530D-03  -0.14590D-04   0.15693D-01  -0.61704D-04   0.29540D-03   0.41311D-04

MODE# 29/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    469.98       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.24015D-01   0.40295D-02  -0.76000D-03   0.67454D-02   0.37564D-02  -0.17554D-01
S1 Engine No:2 +Y-Z               1152     0.33410D-02   0.94906D-02  -0.47745D-02  -0.27767D-02   0.49453D-02  -0.47788D-02
S1 Engine No:3 -Y-Z               1153    -0.56929D-02   0.94910D-02   0.47868D-02  -0.27336D-02  -0.46793D-02  -0.49284D-02
S1 Engine No:4 -Y-Z               1154    -0.26282D-01   0.40646D-02   0.77927D-03   0.66622D-02  -0.34968D-02  -0.17816D-01
S1 Engine No:5 -Y+Z               1155    -0.26113D-01   0.41746D-02  -0.85793D-03  -0.67630D-02   0.36776D-02  -0.17770D-01
S1 Engine No:6 -Y+Z               1156    -0.54757D-02   0.95920D-02  -0.48130D-02   0.28895D-02   0.47489D-02  -0.47852D-02
S1 Engine No:7 +Y+Z               1157     0.33910D-02   0.95745D-02   0.49701D-02   0.27727D-02  -0.49768D-02  -0.47684D-02
S1 Engine No:8 +Y+Z               1158     0.24099D-01   0.40318D-02   0.88044D-03  -0.67766D-02  -0.36630D-02  -0.17663D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04   0.11275D-05  -0.23450D-04   0.66907D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04   0.11275D-05  -0.23450D-04   0.66907D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04   0.11275D-05  -0.23450D-04   0.66907D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.46481D-03  -0.16301D-01  -0.57099D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.22539D-02   0.30321D-01   0.99559D-04  -0.36350D-05   0.34292D-05  -0.80371D-03
Fuel Slosh Mass Locat.             600    -0.55225D-03  -0.52032D-01  -0.17580D-03   0.19510D-05   0.22300D-04  -0.66433D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.29318D-02  -0.41963D-02  -0.13243D-03   0.55670D-04  -0.68479D-04  -0.29448D-02

MODE# 30/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.57       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.14520D-01   0.16899D-01   0.10702D-01   0.12562D-01   0.52750D-02  -0.10533D-01
S1 Engine No:2 +Y-Z               1152     0.87175D-03   0.29839D-01  -0.48949D-03   0.14988D-02   0.59664D-02   0.16595D-02
S1 Engine No:3 -Y-Z               1153     0.38164D-02   0.29787D-01   0.58420D-03   0.18302D-02  -0.65016D-02   0.16534D-02
S1 Engine No:4 -Y-Z               1154    -0.97665D-02   0.16939D-01  -0.10635D-01   0.12186D-01  -0.51992D-02  -0.99815D-02
S1 Engine No:5 -Y+Z               1155    -0.94348D-02   0.79315D-02  -0.12407D-01  -0.30296D-02   0.55208D-02  -0.99463D-02
S1 Engine No:6 -Y+Z               1156     0.41971D-02   0.75439D-02  -0.10263D-01   0.80426D-02   0.65956D-02   0.19655D-02
S1 Engine No:7 +Y+Z               1157     0.63256D-03   0.75885D-02   0.10471D-01   0.83029D-02  -0.60503D-02   0.19140D-02
S1 Engine No:8 +Y+Z               1158     0.14316D-01   0.78453D-02   0.12586D-01  -0.33720D-02  -0.54575D-02  -0.10570D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04   0.17227D-02  -0.31940D-05   0.73841D-03
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04   0.17227D-02  -0.31940D-05   0.73841D-03
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04   0.17227D-02  -0.31940D-05   0.73841D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04
Stage-2 Tank Top, IMU Locat.     40015     0.94925D-03  -0.43196D-02  -0.18701D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.61055D-02   0.19508D-01   0.84140D-04  -0.49544D-02  -0.45258D-05   0.10392D-02
Fuel Slosh Mass Locat.             600     0.14772D-02  -0.15859D-01  -0.70821D-04   0.35551D-02   0.14179D-04  -0.33596D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.66430D-01   0.32924D-01  -0.14575D-04  -0.17130D-02  -0.20296D-04  -0.17123D-01

MODE# 31/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.60       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.14187D-02  -0.57144D-01  -0.13615D+00  -0.57847D-01   0.20054D-03  -0.19020D-02
S1 Engine No:2 +Y-Z               1152    -0.17824D-02  -0.13721D+00  -0.56169D-01  -0.57270D-01   0.20746D-02  -0.59009D-03
S1 Engine No:3 -Y-Z               1153    -0.14292D-02  -0.13695D+00   0.59841D-01  -0.59497D-01   0.79540D-03   0.96168D-03
S1 Engine No:4 -Y-Z               1154    -0.76846D-03  -0.55578D-01   0.14162D+00  -0.56921D-01  -0.77491D-03  -0.56089D-04
S1 Engine No:5 -Y+Z               1155    -0.12351D-02   0.57913D-01   0.14145D+00  -0.58358D-01   0.23052D-03  -0.17821D-02
S1 Engine No:6 -Y+Z               1156     0.19102D-02   0.14046D+00   0.58826D-01  -0.58902D-01   0.19985D-02  -0.57698D-03
S1 Engine No:7 +Y+Z               1157     0.15698D-02   0.14072D+00  -0.55157D-01  -0.56657D-01   0.90886D-03   0.97270D-03
S1 Engine No:8 +Y+Z               1158     0.85113D-03   0.59481D-01  -0.13598D+00  -0.59300D-01  -0.80144D-03   0.27517D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03  -0.21047D-01  -0.97391D-04   0.61472D-04
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03  -0.21047D-01  -0.97391D-04   0.61472D-04
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03  -0.21047D-01  -0.97391D-04   0.61472D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03
Stage-2 Tank Top, IMU Locat.     40015     0.25246D-04  -0.36020D-03  -0.57265D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.16722D-03   0.16350D-02   0.25682D-02   0.60500D-01  -0.13465D-03   0.86219D-04
Fuel Slosh Mass Locat.             600     0.39422D-04  -0.12776D-02  -0.20124D-02  -0.43459D-01   0.45272D-03  -0.28807D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.17711D-02   0.12173D-02   0.18689D-02   0.24649D-01   0.44972D-03  -0.42144D-03

MODE# 32/ 49, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.61       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.18211D-02   0.98862D-03   0.39379D-01   0.35842D-02  -0.23888D-02  -0.71090D-02
S1 Engine No:2 +Y-Z               1152    -0.13284D-01   0.16424D-01   0.21936D-01   0.16288D-01   0.11371D-01  -0.61708D-02
S1 Engine No:3 -Y-Z               1153    -0.13193D-01   0.18517D-01   0.73345D-02  -0.15830D-02   0.11590D-01   0.62470D-02
S1 Engine No:4 -Y-Z               1154     0.23878D-02   0.13454D-01   0.42865D-02   0.11118D-01  -0.23579D-02   0.75022D-02
S1 Engine No:5 -Y+Z               1155    -0.20336D-02  -0.13939D-01   0.43098D-02   0.11322D-01  -0.25039D-02  -0.71874D-02
S1 Engine No:6 -Y+Z               1156     0.13146D-01  -0.19158D-01   0.74654D-02  -0.16978D-02   0.11382D-01  -0.63120D-02
S1 Engine No:7 +Y+Z               1157     0.13367D-01  -0.17065D-01   0.21688D-01   0.16178D-01   0.11605D-01   0.60931D-02
S1 Engine No:8 +Y+Z               1158    -0.22593D-02  -0.13493D-02   0.39340D-01   0.39188D-02  -0.21632D-02   0.74952D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02   0.26777D-02  -0.76211D-03  -0.11544D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02   0.26777D-02  -0.76211D-03  -0.11544D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02   0.26777D-02  -0.76211D-03  -0.11544D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.16679D-05   0.67657D-04  -0.44796D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.11916D-04  -0.30714D-03   0.20161D-01  -0.76963D-02  -0.10567D-02  -0.16225D-04
Fuel Slosh Mass Locat.             600    -0.26205D-05   0.24104D-03  -0.15703D-01   0.55295D-02   0.35646D-02   0.53965D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.14984D-04  -0.43855D-03   0.12458D-01  -0.32281D-02   0.25039D-02   0.21712D-03
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
