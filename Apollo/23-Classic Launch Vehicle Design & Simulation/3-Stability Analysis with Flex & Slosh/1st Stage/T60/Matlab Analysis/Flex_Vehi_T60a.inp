BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=60 sec
! This batch set creates dynamic models for Control Analysis at T=60 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=60.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=60.0 sec 
Actuator Model   : Stage-1 Linear Actuator
!
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=60.0 sec            
To Matlab Format : Mixing Logic for First Stage Model, at T=60.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=60.0 sec                                       
! This is a Launch Vehicle Control Analysis Model at t=60 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 60% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.05 .
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   3940.97       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   29031.4      0.260692E+07  0.260596E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   57.4788       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.76300       816.210       416.620       19772.5    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   22.20         52.9          0.0          -0.2882    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.479        -0.0          -0.020         0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          74.65         0.00000      -0.0          -0.592         0.0
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.000        90.00                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.415        7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.531702      0.00760        0.000335      0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0          -0.07455        0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.03541      -0.07455        0.00000       0.00000       0.00000       0.00000     -0.467511E-04
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.00000       0.00000        0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.1372       -0.286450       0.00000       0.00000       0.00000     -0.260394E-03   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0           0.286450       0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945       -1.0332     
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332       -2.4945 
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332       -2.4945
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945       -1.0332 
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945        1.0332
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332        2.4945
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332        2.4945
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945        1.0332 

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438    0.000      0.000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438    0.000      0.000    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438    0.000      0.000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000       

Number of Slosh Modes                                                                    :  2
LOX Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   565.1   3.11   3.11   0.018  0.018  62.37   0.0  0.0  
LH2 Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   194.6   3.11   3.11   0.01   0.01   32.92   0.0  0.0 

Number of Bending Modes                                                                  : 20
First Stage Flex Modes at 70% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=60.0 sec 
! Thrust Vector Control Matrix at t=60 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=60.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=60.0 sec 
Matrix TVC
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=60.0 sec 
System
flex_vehicle.m
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 70% Full
First Stage Flex Modes at 70% Full Tanks
! Flex Modes, First Stage 70% Full Tanks from Files: Stg1_70%.Mod, Stg1_70%.Nod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    23.165       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.15550D-01   0.13791D+00  -0.40095D-02  -0.27974D-05  -0.18251D-03  -0.64210D-02
S1 Engine No:2 +Y-Z               1152     0.68120D-02   0.13790D+00  -0.40081D-02   0.38291D-06  -0.18164D-03  -0.64368D-02
S1 Engine No:3 -Y-Z               1153    -0.59210D-02   0.13790D+00  -0.40106D-02   0.17814D-06  -0.19171D-03  -0.64370D-02
S1 Engine No:4 -Y-Z               1154    -0.15182D-01   0.13791D+00  -0.40091D-02  -0.25952D-05  -0.19200D-03  -0.64212D-02
S1 Engine No:5 -Y+Z               1155    -0.15552D-01   0.13791D+00  -0.40091D-02   0.28786D-05  -0.18262D-03  -0.64211D-02
S1 Engine No:6 -Y+Z               1156    -0.68146D-02   0.13790D+00  -0.40081D-02  -0.74135D-06  -0.18146D-03  -0.64369D-02
S1 Engine No:7 +Y+Z               1157     0.59186D-02   0.13790D+00  -0.40111D-02  -0.37415D-06  -0.19187D-03  -0.64372D-02
S1 Engine No:8 +Y+Z               1158     0.15179D-01   0.13791D+00  -0.40096D-02   0.29459D-05  -0.19174D-03  -0.64212D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02  -0.17551D-07   0.13211D-03   0.45448D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02  -0.17551D-07   0.13211D-03   0.45448D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02  -0.17551D-07   0.13211D-03   0.45448D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.11284D-05  -0.71681D-01   0.20846D-02  -0.16706D-07   0.10688D-05   0.36280D-04
Fuel Slosh Mass Locat.             600    -0.12406D-05   0.27523D-01  -0.79968D-03  -0.15263D-07  -0.16930D-03  -0.58223D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.52334D-04  -0.90953D-02   0.26381D-03  -0.15445D-07   0.12810D-03   0.44320D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    23.168       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.59220D-02   0.40122D-02   0.13796D+00   0.12325D-06   0.64394D-02  -0.19189D-03
S1 Engine No:2 +Y-Z               1152    -0.15187D-01   0.40109D-02   0.13796D+00  -0.25798D-05   0.64238D-02  -0.19204D-03
S1 Engine No:3 -Y-Z               1153    -0.15557D-01   0.40108D-02   0.13796D+00   0.25105D-05   0.64235D-02  -0.18241D-03
S1 Engine No:4 -Y-Z               1154    -0.68158D-02   0.40099D-02   0.13796D+00  -0.52700D-06   0.64392D-02  -0.18154D-03
S1 Engine No:5 -Y+Z               1155     0.59221D-02   0.40127D-02   0.13796D+00  -0.45282D-06   0.64396D-02  -0.19195D-03
S1 Engine No:6 -Y+Z               1156     0.15187D-01   0.40115D-02   0.13796D+00   0.27085D-05   0.64237D-02  -0.19186D-03
S1 Engine No:7 +Y+Z               1157     0.15557D-01   0.40114D-02   0.13796D+00  -0.28032D-05   0.64235D-02  -0.18247D-03
S1 Engine No:8 +Y+Z               1158     0.68157D-02   0.40100D-02   0.13796D+00   0.32642D-06   0.64393D-02  -0.18155D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01  -0.10910D-06  -0.45445D-02   0.13216D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01  -0.10910D-06  -0.45445D-02   0.13216D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01  -0.10910D-06  -0.45445D-02   0.13216D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.29130D-07  -0.20844D-02  -0.71711D-01  -0.10240D-06  -0.36282D-04   0.10409D-05
Fuel Slosh Mass Locat.             600    -0.32654D-07   0.80100D-03   0.27531D-01  -0.91894D-07   0.58246D-02  -0.16933D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.15264D-05  -0.26466D-03  -0.90811D-02  -0.18142D-06  -0.44068D-02   0.12888D-03

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.781       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.23743D-02  -0.13026D-01  -0.67753D-06   0.10127D-05  -0.12755D-05   0.91836D-03
S1 Engine No:2 +Y-Z               1152    -0.10837D-02  -0.13025D-01  -0.12095D-05  -0.11248D-06  -0.13066D-05   0.92345D-03
S1 Engine No:3 -Y-Z               1153     0.74377D-03  -0.13025D-01  -0.32788D-06  -0.93373D-07   0.15685D-05   0.92330D-03
S1 Engine No:4 -Y-Z               1154     0.20343D-02  -0.13026D-01  -0.85342D-06   0.94314D-06   0.14558D-05   0.91802D-03
S1 Engine No:5 -Y+Z               1155     0.20344D-02  -0.13026D-01  -0.84713D-06  -0.10526D-05  -0.13692D-05   0.91811D-03
S1 Engine No:6 -Y+Z               1156     0.74375D-03  -0.13025D-01  -0.12356D-05   0.24716D-06  -0.16898D-05   0.92335D-03
S1 Engine No:7 +Y+Z               1157    -0.10838D-02  -0.13025D-01  -0.17643D-06   0.16235D-06   0.13207D-05   0.92345D-03
S1 Engine No:8 +Y+Z               1158    -0.23744D-02  -0.13026D-01  -0.68202D-06  -0.10849D-05   0.12176D-05   0.91837D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07   0.76729D-08   0.27582D-07   0.14190D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07   0.76729D-08   0.27582D-07   0.14190D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07   0.76729D-08   0.27582D-07   0.14190D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.14271D-03   0.31476D-02   0.29039D-06   0.60719D-08  -0.12767D-07  -0.63972D-03
Fuel Slosh Mass Locat.             600    -0.16534D-03   0.26775D-02  -0.49008D-06   0.36887D-08  -0.24337D-07   0.71428D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.41687D-02  -0.40163D-01   0.26717D-06   0.71362D-07   0.70616D-07   0.25938D-01

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    52.423       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.12631D-02   0.17219D-05   0.16773D-01   0.78888D-08   0.12762D-02  -0.23600D-05
S1 Engine No:2 +Y-Z               1152    -0.30468D-02   0.75187D-06   0.16775D-01  -0.16874D-05   0.12679D-02  -0.22279D-05
S1 Engine No:3 -Y-Z               1153    -0.30468D-02   0.82134D-06   0.16775D-01   0.14153D-05   0.12679D-02   0.21917D-05
S1 Engine No:4 -Y-Z               1154    -0.12631D-02   0.33683D-06   0.16774D-01  -0.39086D-06   0.12762D-02   0.23857D-05
S1 Engine No:5 -Y+Z               1155     0.12632D-02   0.22278D-05   0.16774D-01  -0.44684D-06   0.12763D-02  -0.23928D-05
S1 Engine No:6 -Y+Z               1156     0.30468D-02   0.16715D-05   0.16775D-01   0.15662D-05   0.12678D-02  -0.21004D-05
S1 Engine No:7 +Y+Z               1157     0.30467D-02   0.17010D-05   0.16775D-01  -0.18240D-05   0.12678D-02   0.21523D-05
S1 Engine No:8 +Y+Z               1158     0.12631D-02   0.64424D-06   0.16773D-01   0.31814D-07   0.12762D-02   0.23784D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02  -0.80027D-07   0.25384D-02   0.54384D-07
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02  -0.80027D-07   0.25384D-02   0.54384D-07
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02  -0.80027D-07   0.25384D-02   0.54384D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.89429D-09  -0.57449D-06   0.74641D-05  -0.13192D-06  -0.11248D-02  -0.27256D-07
Fuel Slosh Mass Locat.             600     0.85507D-09   0.97189D-06  -0.48286D-02  -0.16158D-06   0.93014D-03  -0.40187D-07

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.14439D-07  -0.35999D-06   0.60110D-01   0.46358D-05   0.34082D-01  -0.43470D-07

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.292       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.88383D-02  -0.42388D-01   0.28633D-04   0.70744D-05  -0.43632D-05   0.36929D-02
S1 Engine No:2 +Y-Z               1152    -0.36378D-02  -0.42381D-01   0.24890D-04  -0.84619D-06  -0.51253D-05   0.37260D-02
S1 Engine No:3 -Y-Z               1153     0.37399D-02  -0.42381D-01   0.31008D-04  -0.66689D-06   0.10914D-04   0.37260D-02
S1 Engine No:4 -Y-Z               1154     0.89492D-02  -0.42388D-01   0.27341D-04   0.65297D-05   0.11012D-04   0.36930D-02
S1 Engine No:5 -Y+Z               1155     0.89565D-02  -0.42386D-01   0.27617D-04  -0.74300D-05  -0.39385D-05   0.36936D-02
S1 Engine No:6 -Y+Z               1156     0.37551D-02  -0.42380D-01   0.24863D-04   0.17440D-05  -0.54304D-05   0.37264D-02
S1 Engine No:7 +Y+Z               1157    -0.36232D-02  -0.42380D-01   0.32151D-04   0.11253D-05   0.11607D-04   0.37260D-02
S1 Engine No:8 +Y+Z               1158    -0.88326D-02  -0.42387D-01   0.28477D-04  -0.76895D-05   0.10358D-04   0.36929D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04   0.95668D-07   0.84137D-05   0.10372D-01
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04   0.95668D-07   0.84137D-05   0.10372D-01
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04   0.95668D-07   0.84137D-05   0.10372D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.35923D-04  -0.23364D-01   0.22111D-04   0.55711D-07  -0.35735D-05  -0.43481D-02
Fuel Slosh Mass Locat.             600     0.54019D-04   0.19653D-01  -0.21773D-04   0.40217D-08   0.16496D-05   0.23341D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.11846D-02  -0.91084D-01   0.68191D-04   0.12181D-06  -0.43339D-05   0.37074D-03

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.734       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.35643D-02   0.43613D-04   0.40963D-01   0.57449D-06   0.36072D-02  -0.11121D-04
S1 Engine No:2 +Y-Z               1152    -0.86084D-02   0.40413D-04   0.40969D-01  -0.62916D-05   0.35755D-02  -0.10729D-04
S1 Engine No:3 -Y-Z               1153    -0.86145D-02   0.40825D-04   0.40969D-01   0.62947D-05   0.35756D-02   0.46606D-05
S1 Engine No:4 -Y-Z               1154    -0.35786D-02   0.38082D-04   0.40963D-01  -0.10580D-05   0.36073D-02   0.53785D-05
S1 Engine No:5 -Y+Z               1155     0.35645D-02   0.44618D-04   0.40963D-01  -0.12787D-05   0.36076D-02  -0.11259D-04
S1 Engine No:6 -Y+Z               1156     0.86084D-02   0.41557D-04   0.40970D-01   0.69301D-05   0.35755D-02  -0.10189D-04
S1 Engine No:7 +Y+Z               1157     0.86140D-02   0.41801D-04   0.40970D-01  -0.68719D-05   0.35754D-02   0.44951D-05
S1 Engine No:8 +Y+Z               1158     0.35784D-02   0.38244D-04   0.40963D-01   0.68670D-06   0.36073D-02   0.53466D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01  -0.28380D-07   0.10126D-01  -0.86638D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01  -0.28380D-07   0.10126D-01  -0.86638D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01  -0.28380D-07   0.10126D-01  -0.86638D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.35129D-07   0.16665D-04   0.23135D-01  -0.90401D-07  -0.42318D-02   0.35742D-05
Fuel Slosh Mass Locat.             600    -0.46460D-07  -0.10540D-04  -0.19091D-01  -0.12196D-06   0.22529D-02  -0.21658D-05

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.96870D-06   0.76376D-04   0.82656D-01   0.43830D-05  -0.49943D-02  -0.32402D-06

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    105.16       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.87183D-05   0.18241D-01   0.43981D-01   0.18433D-01  -0.21389D-05  -0.24180D-05
S1 Engine No:2 +Y-Z               1152     0.77367D-05   0.44013D-01   0.18209D-01   0.18433D-01  -0.25492D-05  -0.29365D-05
S1 Engine No:3 -Y-Z               1153     0.17214D-05   0.44013D-01  -0.18239D-01   0.18433D-01  -0.15818D-05  -0.29368D-05
S1 Engine No:4 -Y-Z               1154    -0.51446D-05   0.18241D-01  -0.44012D-01   0.18433D-01  -0.20846D-05  -0.24756D-05
S1 Engine No:5 -Y+Z               1155    -0.94842D-05  -0.18207D-01  -0.44012D-01   0.18433D-01  -0.20910D-05  -0.34237D-05
S1 Engine No:6 -Y+Z               1156    -0.81530D-05  -0.43979D-01  -0.18239D-01   0.18433D-01  -0.16414D-05  -0.29576D-05
S1 Engine No:7 +Y+Z               1157    -0.24976D-05  -0.43979D-01   0.18209D-01   0.18433D-01  -0.25831D-05  -0.29686D-05
S1 Engine No:8 +Y+Z               1158     0.47149D-05  -0.18207D-01   0.43981D-01   0.18433D-01  -0.21140D-05  -0.33794D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04  -0.19519D-01  -0.19493D-05  -0.15481D-05
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04  -0.19519D-01  -0.19493D-05  -0.15481D-05
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04  -0.19519D-01  -0.19493D-05  -0.15481D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.52208D-07   0.19768D-04  -0.16391D-04   0.25034D-02   0.12001D-05   0.12089D-05
Fuel Slosh Mass Locat.             600    -0.18076D-06  -0.23278D-04   0.15433D-04   0.15432D-01  -0.69907D-06  -0.69240D-06

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.53740D-06   0.12003D-04  -0.21088D-04  -0.31561D+00  -0.57034D-05  -0.14023D-05

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    109.14       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.25200D-01   0.80058D-01  -0.51624D-02  -0.30637D-04  -0.66875D-03  -0.10341D-01
S1 Engine No:2 +Y-Z               1152     0.11560D-01   0.80028D-01  -0.51519D-02   0.11118D-04  -0.65851D-03  -0.10465D-01
S1 Engine No:3 -Y-Z               1153    -0.91652D-02   0.80028D-01  -0.51901D-02   0.60340D-05  -0.68563D-03  -0.10468D-01
S1 Engine No:4 -Y-Z               1154    -0.24709D-01   0.80058D-01  -0.51759D-02  -0.26922D-04  -0.69704D-03  -0.10347D-01
S1 Engine No:5 -Y+Z               1155    -0.26067D-01   0.80038D-01  -0.51795D-02   0.42496D-04  -0.67272D-03  -0.10348D-01
S1 Engine No:6 -Y+Z               1156    -0.12422D-01   0.79999D-01  -0.51613D-02  -0.69611D-05  -0.65993D-03  -0.10469D-01
S1 Engine No:7 +Y+Z               1157     0.83073D-02   0.79999D-01  -0.51876D-02   0.10664D-05  -0.69256D-03  -0.10467D-01
S1 Engine No:8 +Y+Z               1158     0.23851D-01   0.80045D-01  -0.51596D-02   0.43313D-04  -0.69467D-03  -0.10343D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02  -0.71111D-05  -0.58105D-03  -0.91090D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02  -0.71111D-05  -0.58105D-03  -0.91090D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02  -0.71111D-05  -0.58105D-03  -0.91090D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.52086D-05   0.81940D-01  -0.53014D-02  -0.15496D-05   0.37590D-03   0.58519D-02
Fuel Slosh Mass Locat.             600    -0.32492D-03  -0.75176D-01   0.49178D-02   0.31368D-05  -0.23357D-03  -0.36306D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.15582D-02   0.70509D-01  -0.43331D-02   0.19550D-03  -0.36396D-03  -0.77382D-02

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    109.67       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.87107D-02   0.53151D-02   0.81898D-01   0.68819D-05   0.10371D-01  -0.67382D-03
S1 Engine No:2 +Y-Z               1152    -0.24099D-01   0.53041D-02   0.81925D-01  -0.26263D-04   0.10244D-01  -0.68219D-03
S1 Engine No:3 -Y-Z               1153    -0.25415D-01   0.53083D-02   0.81910D-01   0.39185D-04   0.10242D-01  -0.64621D-03
S1 Engine No:4 -Y-Z               1154    -0.11877D-01   0.52875D-02   0.81870D-01  -0.18780D-05   0.10369D-01  -0.63594D-03
S1 Engine No:5 -Y+Z               1155     0.86627D-02   0.53082D-02   0.81870D-01   0.14603D-05   0.10372D-01  -0.67501D-03
S1 Engine No:6 -Y+Z               1156     0.24050D-01   0.52810D-02   0.81915D-01   0.42085D-04   0.10243D-01  -0.67920D-03
S1 Engine No:7 +Y+Z               1157     0.25363D-01   0.52843D-02   0.81926D-01  -0.30389D-04   0.10240D-01  -0.64709D-03
S1 Engine No:8 +Y+Z               1158     0.11827D-01   0.52760D-02   0.81898D-01   0.12358D-04   0.10369D-01  -0.63598D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01  -0.61858D-05   0.95567D-02  -0.62633D-03
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01  -0.61858D-05   0.95567D-02  -0.62633D-03
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01  -0.61858D-05   0.95567D-02  -0.62633D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.13277D-05   0.53628D-02   0.83039D-01   0.92104D-06  -0.60229D-02   0.39192D-03
Fuel Slosh Mass Locat.             600    -0.19221D-04  -0.46963D-02  -0.73635D-01   0.47174D-05   0.37556D-02  -0.24395D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.10084D-03   0.48422D-02   0.71211D-01  -0.68554D-04   0.59428D-02  -0.52751D-03

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    112.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.93662D-05   0.23058D-01   0.55768D-01   0.23366D-01  -0.92538D-06   0.46850D-05
S1 Engine No:2 +Y-Z               1152    -0.22618D-05   0.55728D-01   0.23098D-01   0.23366D-01  -0.15552D-05   0.40442D-05
S1 Engine No:3 -Y-Z               1153     0.54721D-05   0.55728D-01  -0.23104D-01   0.23366D-01  -0.11462D-06   0.40553D-05
S1 Engine No:4 -Y-Z               1154     0.10161D-04   0.23058D-01  -0.55774D-01   0.23366D-01  -0.81298D-06   0.46126D-05
S1 Engine No:5 -Y+Z               1155     0.82152D-05  -0.23144D-01  -0.55774D-01   0.23366D-01  -0.85463D-06   0.32232D-05
S1 Engine No:6 -Y+Z               1156     0.16167D-05  -0.55814D-01  -0.23104D-01   0.23366D-01  -0.23843D-06   0.40162D-05
S1 Engine No:7 +Y+Z               1157    -0.66464D-05  -0.55814D-01   0.23098D-01   0.23366D-01  -0.15698D-05   0.40103D-05
S1 Engine No:8 +Y+Z               1158    -0.10829D-04  -0.23144D-01   0.55768D-01   0.23366D-01  -0.85909D-06   0.32999D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05  -0.29766D-01   0.61900D-06   0.65926D-05
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05  -0.29766D-01   0.61900D-06   0.65926D-05
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05  -0.29766D-01   0.61900D-06   0.65926D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.89976D-07  -0.42315D-04  -0.23868D-05   0.10532D-02  -0.77256D-07  -0.35610D-05
Fuel Slosh Mass Locat.             600    -0.27510D-06   0.25494D-04   0.70629D-05   0.19020D-01  -0.20095D-07   0.21922D-05

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.23209D-06  -0.50491D-04   0.96230D-05   0.22494D+00   0.37220D-05   0.53038D-05

MODE# 11/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    125.79       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.23477D-01  -0.37360D-01   0.29625D-02   0.31690D-04   0.70494D-03   0.84546D-02
S1 Engine No:2 +Y-Z               1152    -0.12650D-01  -0.37320D-01   0.29371D-02   0.71638D-05   0.71615D-03   0.84600D-02
S1 Engine No:3 -Y-Z               1153     0.40454D-02  -0.37319D-01   0.29300D-02   0.10374D-04   0.66167D-03   0.84392D-02
S1 Engine No:4 -Y-Z               1154     0.16744D-01  -0.37359D-01   0.29010D-02   0.29248D-04   0.65681D-03   0.84122D-02
S1 Engine No:5 -Y+Z               1155     0.18076D-01  -0.37372D-01   0.29057D-02  -0.12194D-04   0.69000D-03   0.84190D-02
S1 Engine No:6 -Y+Z               1156     0.72438D-02  -0.37366D-01   0.29142D-02   0.19027D-04   0.67646D-03   0.84452D-02
S1 Engine No:7 +Y+Z               1157    -0.94540D-02  -0.37366D-01   0.29554D-02   0.12730D-04   0.62611D-03   0.84562D-02
S1 Engine No:8 +Y+Z               1158    -0.22152D-01  -0.37378D-01   0.29567D-02  -0.12468D-04   0.63700D-03   0.84504D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03  -0.18386D-04  -0.74520D-03  -0.92041D-02
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03  -0.18386D-04  -0.74520D-03  -0.92041D-02
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03  -0.18386D-04  -0.74520D-03  -0.92041D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.47265D-03  -0.12763D-01   0.96494D-03   0.64663D-05   0.13202D-03   0.15952D-02
Fuel Slosh Mass Locat.             600    -0.23257D-02   0.61932D-01  -0.49279D-02   0.12586D-04   0.40416D-04   0.54295D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.40998D-02   0.64433D-01  -0.50637D-02   0.33564D-04  -0.38874D-03  -0.62719D-02

MODE# 12/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    130.33       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.10100D-01   0.63304D-02   0.77416D-01   0.34349D-05   0.12784D-01  -0.10215D-02
S1 Engine No:2 +Y-Z               1152    -0.29351D-01   0.63073D-02   0.77462D-01  -0.39294D-04   0.12667D-01  -0.10334D-02
S1 Engine No:3 -Y-Z               1153    -0.31407D-01   0.63158D-02   0.77450D-01   0.47026D-04   0.12668D-01  -0.10441D-02
S1 Engine No:4 -Y-Z               1154    -0.15045D-01   0.62959D-02   0.77402D-01  -0.84978D-05   0.12786D-01  -0.10336D-02
S1 Engine No:5 -Y+Z               1155     0.10255D-01   0.63315D-02   0.77402D-01  -0.25352D-05   0.12787D-01  -0.10217D-02
S1 Engine No:6 -Y+Z               1156     0.29504D-01   0.63006D-02   0.77457D-01   0.51032D-04   0.12667D-01  -0.10284D-02
S1 Engine No:7 +Y+Z               1157     0.31555D-01   0.63077D-02   0.77462D-01  -0.45578D-04   0.12667D-01  -0.10460D-02
S1 Engine No:8 +Y+Z               1158     0.15198D-01   0.62902D-02   0.77416D-01   0.12510D-04   0.12787D-01  -0.10352D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02  -0.51385D-05  -0.10456D-01   0.83935D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02  -0.51385D-05  -0.10456D-01   0.83935D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02  -0.51385D-05  -0.10456D-01   0.83935D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.24372D-04   0.30574D-02   0.37230D-01   0.22226D-05   0.53663D-03  -0.40063D-04
Fuel Slosh Mass Locat.             600     0.71908D-04  -0.72213D-02  -0.88983D-01   0.32897D-05   0.22026D-02  -0.18067D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.17362D-03  -0.55829D-02  -0.67625D-01   0.26948D-04  -0.51233D-02   0.53093D-03

MODE# 13/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    143.17       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.27631D-01  -0.10983D+00   0.89210D-02   0.91120D-04   0.86302D-03   0.11065D-01
S1 Engine No:2 +Y-Z               1152    -0.13014D-01  -0.10974D+00   0.88764D-02  -0.16187D-04   0.82622D-03   0.11429D-01
S1 Engine No:3 -Y-Z               1153     0.97033D-02  -0.10974D+00   0.89490D-02  -0.93682D-06   0.96103D-03   0.11442D-01
S1 Engine No:4 -Y-Z               1154     0.26906D-01  -0.10983D+00   0.88931D-02   0.81682D-04   0.99641D-03   0.11084D-01
S1 Engine No:5 -Y+Z               1155     0.28766D-01  -0.10981D+00   0.88970D-02  -0.92485D-04   0.87235D-03   0.11080D-01
S1 Engine No:6 -Y+Z               1156     0.14137D-01  -0.10974D+00   0.88720D-02   0.33662D-04   0.82909D-03   0.11438D-01
S1 Engine No:7 +Y+Z               1157    -0.85892D-02  -0.10974D+00   0.89703D-02   0.11010D-04   0.97657D-03   0.11440D-01
S1 Engine No:8 +Y+Z               1158    -0.25792D-01  -0.10983D+00   0.89189D-02  -0.93733D-04   0.99043D-03   0.11077D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03   0.11296D-04  -0.63011D-03  -0.77250D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03   0.11296D-04  -0.63011D-03  -0.77250D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03   0.11296D-04  -0.63011D-03  -0.77250D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.32071D-03  -0.73955D-01   0.59980D-02  -0.82990D-05  -0.20558D-03  -0.25409D-02
Fuel Slosh Mass Locat.             600     0.63387D-03   0.76547D-01  -0.62183D-02  -0.45654D-05   0.39862D-03   0.49130D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.28389D-03   0.40968D-01  -0.32643D-02  -0.71724D-05  -0.22320D-03  -0.34642D-02

MODE# 14/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    150.00       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.50203D-02   0.64385D-02   0.78979D-01   0.82655D-05   0.62018D-02  -0.55928D-03
S1 Engine No:2 +Y-Z               1152    -0.14345D-01   0.64070D-02   0.79038D-01  -0.59785D-04   0.58723D-02  -0.58258D-03
S1 Engine No:3 -Y-Z               1153    -0.15349D-01   0.64080D-02   0.79019D-01   0.73248D-04   0.58598D-02  -0.42329D-03
S1 Engine No:4 -Y-Z               1154    -0.74201D-02   0.63759D-02   0.78954D-01  -0.12913D-04   0.61902D-02  -0.38924D-03
S1 Engine No:5 -Y+Z               1155     0.49433D-02   0.64361D-02   0.78953D-01  -0.33470D-05   0.62042D-02  -0.56164D-03
S1 Engine No:6 -Y+Z               1156     0.14266D-01   0.63900D-02   0.79029D-01   0.77383D-04   0.58709D-02  -0.57756D-03
S1 Engine No:7 +Y+Z               1157     0.15265D-01   0.63894D-02   0.79037D-01  -0.67651D-04   0.58564D-02  -0.42460D-03
S1 Engine No:8 +Y+Z               1158     0.73403D-02   0.63654D-02   0.78979D-01   0.21378D-04   0.61904D-02  -0.38904D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.77628D-04  -0.40158D-03  -0.49754D-02   0.77587D-05  -0.53465D-02   0.43208D-03
Stage-2 Tank Top, IMU Locat.     40015     0.77628D-04  -0.40158D-03  -0.49754D-02   0.77587D-05  -0.53465D-02   0.43208D-03
Stage-2 Tank Top, IMU Locat.     40015     0.77628D-04  -0.40158D-03  -0.49754D-02   0.77587D-05  -0.53465D-02   0.43208D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.77628D-04  -0.40158D-03  -0.49754D-02
Stage-2 Tank Top, IMU Locat.     40015     0.77628D-04  -0.40158D-03  -0.49754D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.42895D-04   0.54272D-02   0.66954D-01  -0.69098D-05  -0.29034D-02   0.23546D-03
Fuel Slosh Mass Locat.             600    -0.58577D-04  -0.35708D-02  -0.44082D-01  -0.14366D-05   0.43168D-02  -0.34986D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.59203D-04  -0.18695D-02  -0.22681D-01   0.28466D-06  -0.12793D-02   0.13123D-03

MODE# 15/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    186.28       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.82649D-04  -0.43875D-01  -0.10638D+00  -0.44518D-01  -0.20634D-04  -0.29204D-04
S1 Engine No:2 +Y-Z               1152     0.74512D-04  -0.10612D+00  -0.44133D-01  -0.44518D-01  -0.16921D-04  -0.25622D-04
S1 Engine No:3 -Y-Z               1153     0.25552D-04  -0.10612D+00   0.43902D-01  -0.44518D-01  -0.24302D-04  -0.25547D-04
S1 Engine No:4 -Y-Z               1154    -0.40104D-04  -0.43875D-01   0.10615D+00  -0.44518D-01  -0.20850D-04  -0.28654D-04
S1 Engine No:5 -Y+Z               1155    -0.79868D-04   0.44160D-01   0.10615D+00  -0.44516D-01  -0.21000D-04  -0.21332D-04
S1 Engine No:6 -Y+Z               1156    -0.74584D-04   0.10641D+00   0.43902D-01  -0.44518D-01  -0.24019D-04  -0.25567D-04
S1 Engine No:7 +Y+Z               1157    -0.22567D-04   0.10641D+00  -0.44133D-01  -0.44516D-01  -0.16457D-04  -0.25346D-04
S1 Engine No:8 +Y+Z               1158     0.40182D-04   0.44160D-01  -0.10638D+00  -0.44518D-01  -0.20639D-04  -0.21564D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.54275D-06   0.19711D-04  -0.15957D-04  -0.99660D-02  -0.35924D-05  -0.44312D-05
Stage-2 Tank Top, IMU Locat.     40015     0.54275D-06   0.19711D-04  -0.15957D-04  -0.99660D-02  -0.35924D-05  -0.44312D-05
Stage-2 Tank Top, IMU Locat.     40015     0.54275D-06   0.19711D-04  -0.15957D-04  -0.99660D-02  -0.35924D-05  -0.44312D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.54275D-06   0.19711D-04  -0.15957D-04
Stage-2 Tank Top, IMU Locat.     40015     0.54275D-06   0.19711D-04  -0.15957D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.55049D-06  -0.11939D-03   0.97512D-04   0.17734D-01  -0.68378D-05  -0.83790D-05
Fuel Slosh Mass Locat.             600    -0.89572D-08  -0.11292D-03   0.92260D-04  -0.22516D-01   0.13472D-05   0.16121D-05

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.90723D-06  -0.27785D-04   0.21237D-04   0.13969D-02   0.55321D-05   0.79524D-05

MODE# 16/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    196.11       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.58815D-01   0.16126D+00  -0.12531D-01  -0.19404D-03  -0.18601D-02  -0.22975D-01
S1 Engine No:2 +Y-Z               1152     0.28613D-01   0.16108D+00  -0.12494D-01   0.12091D-03  -0.18107D-02  -0.23722D-01
S1 Engine No:3 -Y-Z               1153    -0.18430D-01   0.16108D+00  -0.12842D-01   0.77765D-04  -0.18185D-02  -0.23711D-01
S1 Engine No:4 -Y-Z               1154    -0.53798D-01   0.16126D+00  -0.12773D-01  -0.16222D-03  -0.19028D-02  -0.22949D-01
S1 Engine No:5 -Y+Z               1155    -0.57550D-01   0.16104D+00  -0.12794D-01   0.34516D-03  -0.18680D-02  -0.22973D-01
S1 Engine No:6 -Y+Z               1156    -0.27306D-01   0.16072D+00  -0.12619D-01  -0.37390D-04  -0.17647D-02  -0.23732D-01
S1 Engine No:7 +Y+Z               1157     0.19771D-01   0.16072D+00  -0.12772D-01   0.32975D-04  -0.18131D-02  -0.23728D-01
S1 Engine No:8 +Y+Z               1158     0.55136D-01   0.16110D+00  -0.12515D-01   0.34948D-03  -0.18564D-02  -0.22979D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.48482D-03   0.16553D-01  -0.12914D-02   0.11210D-04  -0.21791D-03  -0.27906D-02
Stage-2 Tank Top, IMU Locat.     40015     0.48482D-03   0.16553D-01  -0.12914D-02   0.11210D-04  -0.21791D-03  -0.27906D-02
Stage-2 Tank Top, IMU Locat.     40015     0.48482D-03   0.16553D-01  -0.12914D-02   0.11210D-04  -0.21791D-03  -0.27906D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.48482D-03   0.16553D-01  -0.12914D-02
Stage-2 Tank Top, IMU Locat.     40015     0.48482D-03   0.16553D-01  -0.12914D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.50568D-03  -0.83880D-01   0.66042D-02  -0.22790D-04  -0.50538D-03  -0.64255D-02
Fuel Slosh Mass Locat.             600     0.12639D-03  -0.11067D+00   0.87064D-02   0.37555D-04  -0.56503D-04  -0.72337D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.14844D-02  -0.33692D-01   0.25124D-02  -0.13721D-05   0.60943D-03   0.89208D-02

MODE# 17/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    197.33       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.18973D-01   0.12923D-01   0.16341D+00  -0.31318D-04   0.23666D-01  -0.18319D-02
S1 Engine No:2 +Y-Z               1152    -0.54302D-01   0.12716D-01   0.16373D+00  -0.27286D-03   0.22903D-01  -0.19039D-02
S1 Engine No:3 -Y-Z               1153    -0.58005D-01   0.12743D-01   0.16378D+00   0.19932D-03   0.22903D-01  -0.18247D-02
S1 Engine No:4 -Y-Z               1154    -0.27814D-01   0.12713D-01   0.16362D+00  -0.11254D-03   0.23666D-01  -0.17596D-02
S1 Engine No:5 -Y+Z               1155     0.19161D-01   0.13046D-01   0.16361D+00  -0.79589D-04   0.23680D-01  -0.18352D-02
S1 Engine No:6 -Y+Z               1156     0.54480D-01   0.12960D-01   0.16382D+00   0.21934D-03   0.22902D-01  -0.18779D-02
S1 Engine No:7 +Y+Z               1157     0.58159D-01   0.12979D-01   0.16373D+00  -0.30700D-03   0.22894D-01  -0.18329D-02
S1 Engine No:8 +Y+Z               1158     0.27988D-01   0.12798D-01   0.16341D+00   0.14790D-04   0.23670D-01  -0.17656D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.52880D-04   0.12945D-02   0.16329D-01  -0.74693D-05   0.26596D-02  -0.21065D-03
Stage-2 Tank Top, IMU Locat.     40015     0.52880D-04   0.12945D-02   0.16329D-01  -0.74693D-05   0.26596D-02  -0.21065D-03
Stage-2 Tank Top, IMU Locat.     40015     0.52880D-04   0.12945D-02   0.16329D-01  -0.74693D-05   0.26596D-02  -0.21065D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.52880D-04   0.12945D-02   0.16329D-01
Stage-2 Tank Top, IMU Locat.     40015     0.52880D-04   0.12945D-02   0.16329D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.63529D-04  -0.64042D-02  -0.81565D-01   0.15491D-04   0.63102D-02  -0.49601D-03
Fuel Slosh Mass Locat.             600     0.19552D-04  -0.87308D-02  -0.11111D+00  -0.26260D-04   0.93721D-03  -0.74063D-04

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.10506D-03  -0.27276D-02  -0.32901D-01   0.46883D-05  -0.79572D-02   0.71975D-03

MODE# 18/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    241.24       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13749D-02   0.83136D-02   0.15800D-04  -0.21827D-04   0.48108D-04  -0.11759D-02
S1 Engine No:2 +Y-Z               1152    -0.32238D-02   0.82936D-02   0.29073D-04   0.57214D-05   0.11185D-03  -0.12966D-02
S1 Engine No:3 -Y-Z               1153    -0.58974D-02   0.82985D-02   0.70816D-05   0.34033D-05   0.12378D-03  -0.13996D-02
S1 Engine No:4 -Y-Z               1154    -0.77436D-02   0.83214D-02   0.16368D-04  -0.17975D-04   0.55249D-04  -0.14080D-02
S1 Engine No:5 -Y+Z               1155    -0.77466D-02   0.83117D-02   0.10151D-04   0.24761D-04  -0.57311D-04  -0.14107D-02
S1 Engine No:6 -Y+Z               1156    -0.58940D-02   0.82876D-02   0.18961D-04  -0.62806D-05  -0.11909D-03  -0.14022D-02
S1 Engine No:7 +Y+Z               1157    -0.32169D-02   0.82832D-02  -0.47350D-05  -0.46970D-05  -0.11064D-03  -0.12968D-02
S1 Engine No:8 +Y+Z               1158    -0.13710D-02   0.83074D-02   0.11941D-04   0.27076D-04  -0.44894D-04  -0.11755D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.30229D-01  -0.16265D-01   0.55162D-05   0.88482D-07   0.21749D-06   0.66203D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.30229D-01  -0.16265D-01   0.55162D-05   0.88482D-07   0.21749D-06   0.66203D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.30229D-01  -0.16265D-01   0.55162D-05   0.88482D-07   0.21749D-06   0.66203D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.30229D-01  -0.16265D-01   0.55162D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.30229D-01  -0.16265D-01   0.55162D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.17341D-02   0.19426D-02  -0.49868D-05  -0.28519D-06   0.80346D-06   0.12216D-02
Fuel Slosh Mass Locat.             600    -0.14115D-02  -0.29262D-02  -0.82579D-05   0.97926D-06   0.57103D-06   0.24242D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.48227D+00   0.95909D-01  -0.22976D-04   0.57541D-08  -0.65456D-05  -0.39497D-01

MODE# 19/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    248.47       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.12950D-01   0.32069D-01  -0.68449D-04  -0.88114D-04  -0.44572D-04  -0.50923D-02
S1 Engine No:2 +Y-Z               1152     0.57118D-02   0.31977D-01  -0.20558D-04   0.21222D-04  -0.54791D-04  -0.53128D-02
S1 Engine No:3 -Y-Z               1153    -0.48096D-02   0.31977D-01  -0.11371D-03   0.18314D-04   0.55853D-05  -0.52999D-02
S1 Engine No:4 -Y-Z               1154    -0.12091D-01   0.32063D-01  -0.67662D-04  -0.77695D-04  -0.55877D-05  -0.50663D-02
S1 Engine No:5 -Y+Z               1155    -0.12142D-01   0.32023D-01  -0.72847D-04   0.10649D-03  -0.41765D-04  -0.50778D-02
S1 Engine No:6 -Y+Z               1156    -0.48878D-02   0.31930D-01  -0.27822D-04  -0.29722D-04  -0.23465D-04  -0.53111D-02
S1 Engine No:7 +Y+Z               1157     0.56486D-02   0.31932D-01  -0.12717D-03  -0.16686D-04   0.22248D-04  -0.53137D-02
S1 Engine No:8 +Y+Z               1158     0.12928D-01   0.32042D-01  -0.64365D-04   0.11091D-03   0.19584D-04  -0.50912D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.75669D-02  -0.66798D-01   0.22826D-03   0.35622D-06   0.65784D-05   0.19336D-02
Stage-2 Tank Top, IMU Locat.     40015     0.75669D-02  -0.66798D-01   0.22826D-03   0.35622D-06   0.65784D-05   0.19336D-02
Stage-2 Tank Top, IMU Locat.     40015     0.75669D-02  -0.66798D-01   0.22826D-03   0.35622D-06   0.65784D-05   0.19336D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.75669D-02  -0.66798D-01   0.22826D-03
Stage-2 Tank Top, IMU Locat.     40015     0.75669D-02  -0.66798D-01   0.22826D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.12581D-03   0.15571D-01  -0.65448D-04  -0.12113D-05   0.21053D-04   0.58105D-02
Fuel Slosh Mass Locat.             600     0.50251D-04  -0.96940D-02   0.98020D-05   0.45178D-05   0.52753D-05   0.10726D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.12829D+00   0.31022D+00  -0.10318D-02   0.92346D-07  -0.30706D-03  -0.95732D-01

MODE# 20/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    249.05       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.54414D-02   0.17771D-03   0.33605D-01   0.10821D-04   0.55322D-02   0.37126D-05
S1 Engine No:2 +Y-Z               1152    -0.13056D-01   0.12504D-03   0.33700D-01  -0.89300D-04   0.53023D-02  -0.56116D-05
S1 Engine No:3 -Y-Z               1153    -0.13101D-01   0.13341D-03   0.33701D-01   0.85424D-04   0.53032D-02  -0.38268D-04
S1 Engine No:4 -Y-Z               1154    -0.55404D-02   0.97084D-04   0.33619D-01  -0.26705D-04   0.55348D-02  -0.39931D-04
S1 Engine No:5 -Y+Z               1155     0.54405D-02   0.20434D-03   0.33619D-01  -0.28204D-04   0.55376D-02   0.21929D-05
S1 Engine No:6 -Y+Z               1156     0.13049D-01   0.15992D-03   0.33711D-01   0.96755D-04   0.52998D-02   0.50653D-05
S1 Engine No:7 +Y+Z               1157     0.13082D-01   0.16527D-03   0.33710D-01  -0.10012D-03   0.52982D-02  -0.40177D-04
S1 Engine No:8 +Y+Z               1158     0.55306D-02   0.10492D-03   0.33605D-01   0.11647D-04   0.55331D-02  -0.40960D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.22160D-04  -0.21930D-03  -0.69180D-01  -0.69431D-06  -0.19406D-02   0.61822D-05
Stage-2 Tank Top, IMU Locat.     40015     0.22160D-04  -0.21930D-03  -0.69180D-01  -0.69431D-06  -0.19406D-02   0.61822D-05
Stage-2 Tank Top, IMU Locat.     40015     0.22160D-04  -0.21930D-03  -0.69180D-01  -0.69431D-06  -0.19406D-02   0.61822D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.22160D-04  -0.21930D-03  -0.69180D-01
Stage-2 Tank Top, IMU Locat.     40015     0.22160D-04  -0.21930D-03  -0.69180D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.16908D-05   0.39894D-04   0.16567D-01   0.10616D-05  -0.60666D-02   0.17986D-04
Fuel Slosh Mass Locat.             600    -0.30741D-05  -0.56129D-04  -0.10253D-01  -0.39608D-05  -0.10960D-02   0.17951D-05

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.39041D-03   0.10270D-02   0.31474D+00  -0.29010D-04   0.94002D-01  -0.31876D-03

MODE# 21/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    264.30       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.29968D-01   0.66925D-01  -0.46326D-02  -0.21577D-03  -0.99208D-03  -0.12071D-01
S1 Engine No:2 +Y-Z               1152     0.14101D-01   0.66711D-01  -0.45321D-02   0.73661D-04  -0.97362D-03  -0.12529D-01
S1 Engine No:3 -Y-Z               1153    -0.10676D-01   0.66710D-01  -0.47727D-02   0.38227D-04  -0.68434D-03  -0.12517D-01
S1 Engine No:4 -Y-Z               1154    -0.28934D-01   0.66926D-01  -0.46507D-02  -0.18118D-03  -0.77118D-03  -0.12067D-01
S1 Engine No:5 -Y+Z               1155    -0.30719D-01   0.66793D-01  -0.46671D-02   0.27566D-03  -0.10222D-02  -0.12113D-01
S1 Engine No:6 -Y+Z               1156    -0.14809D-01   0.66560D-01  -0.45634D-02  -0.89896D-04  -0.97165D-03  -0.12564D-01
S1 Engine No:7 +Y+Z               1157     0.10012D-01   0.66563D-01  -0.48067D-02  -0.24110D-04  -0.71897D-03  -0.12518D-01
S1 Engine No:8 +Y+Z               1158     0.28262D-01   0.66857D-01  -0.46225D-02   0.28112D-03  -0.73966D-03  -0.12052D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.29740D-03   0.64387D-02  -0.48724D-03   0.10375D-05  -0.53472D-05  -0.73198D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.29740D-03   0.64387D-02  -0.48724D-03   0.10375D-05  -0.53472D-05  -0.73198D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.29740D-03   0.64387D-02  -0.48724D-03   0.10375D-05  -0.53472D-05  -0.73198D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.29740D-03   0.64387D-02  -0.48724D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.29740D-03   0.64387D-02  -0.48724D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.11227D-03   0.42631D-02  -0.28419D-03  -0.39881D-05   0.42083D-04   0.65453D-03
Fuel Slosh Mass Locat.             600    -0.21142D-03  -0.31927D-01   0.22306D-02   0.17489D-04   0.83716D-04   0.11988D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.48327D-02  -0.36619D-01   0.26394D-02  -0.19457D-06   0.86944D-03   0.12695D-01

MODE# 22/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    264.41       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.10412D-01  -0.48615D-02  -0.67680D-01  -0.99396D-05  -0.12596D-01   0.73190D-03
S1 Engine No:2 +Y-Z               1152     0.28843D-01  -0.47147D-02  -0.67922D-01   0.21080D-03  -0.12158D-01   0.79109D-03
S1 Engine No:3 -Y-Z               1153     0.30614D-01  -0.47370D-02  -0.67913D-01  -0.20266D-03  -0.12181D-01   0.99455D-03
S1 Engine No:4 -Y-Z               1154     0.14599D-01  -0.46693D-02  -0.67730D-01   0.83573D-04  -0.12619D-01   0.97448D-03
S1 Engine No:5 -Y+Z               1155    -0.10364D-01  -0.49276D-02  -0.67728D-01   0.55790D-04  -0.12608D-01   0.73789D-03
S1 Engine No:6 -Y+Z               1156    -0.28782D-01  -0.48085D-02  -0.67953D-01  -0.22252D-03  -0.12152D-01   0.76613D-03
S1 Engine No:7 +Y+Z               1157    -0.30525D-01  -0.48235D-02  -0.67930D-01   0.24467D-03  -0.12166D-01   0.99898D-03
S1 Engine No:8 +Y+Z               1158    -0.14533D-01  -0.46906D-02  -0.67681D-01  -0.44429D-04  -0.12616D-01   0.97640D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.21213D-04  -0.43901D-03  -0.67550D-02   0.70350D-06  -0.73388D-04   0.49430D-05
Stage-2 Tank Top, IMU Locat.     40015     0.21213D-04  -0.43901D-03  -0.67550D-02   0.70350D-06  -0.73388D-04   0.49430D-05
Stage-2 Tank Top, IMU Locat.     40015     0.21213D-04  -0.43901D-03  -0.67550D-02   0.70350D-06  -0.73388D-04   0.49430D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.21213D-04  -0.43901D-03  -0.67550D-02
Stage-2 Tank Top, IMU Locat.     40015     0.21213D-04  -0.43901D-03  -0.67550D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10600D-04  -0.28823D-03  -0.39063D-02  -0.28736D-05   0.60074D-03  -0.45820D-04
Fuel Slosh Mass Locat.             600     0.19994D-04   0.22923D-02   0.32581D-01   0.12623D-04   0.11616D-02  -0.81785D-04

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.32875D-03   0.25006D-02   0.36645D-01  -0.31043D-05   0.12080D-01  -0.86755D-03

MODE# 23/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    280.81       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.52021D-03  -0.17272D-02  -0.82139D-02  -0.30144D-02  -0.11939D-03  -0.12858D-03
S1 Engine No:2 +Y-Z               1152     0.48743D-03  -0.59380D-02  -0.40068D-02  -0.30037D-02  -0.10613D-03  -0.14402D-03
S1 Engine No:3 -Y-Z               1153     0.19785D-03  -0.59380D-02   0.19392D-02  -0.30115D-02  -0.10987D-03  -0.14500D-03
S1 Engine No:4 -Y-Z               1154    -0.16070D-03  -0.17238D-02   0.61533D-02  -0.30120D-02  -0.12288D-03  -0.12692D-03
S1 Engine No:5 -Y+Z               1155    -0.40253D-03   0.42207D-02   0.61536D-02  -0.30016D-02  -0.11822D-03  -0.12354D-03
S1 Engine No:6 -Y+Z               1156    -0.36915D-03   0.84260D-02   0.19441D-02  -0.30149D-02  -0.10263D-03  -0.14315D-03
S1 Engine No:7 +Y+Z               1157    -0.77604D-04   0.84263D-02  -0.40136D-02  -0.30055D-02  -0.10450D-03  -0.14700D-03
S1 Engine No:8 +Y+Z               1158     0.27986D-03   0.42265D-02  -0.82140D-02  -0.30032D-02  -0.12010D-03  -0.12992D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.59762D-05  -0.26346D-04   0.22905D-04  -0.13618D-03   0.45424D-07   0.78342D-07
Stage-2 Tank Top, IMU Locat.     40015     0.59762D-05  -0.26346D-04   0.22905D-04  -0.13618D-03   0.45424D-07   0.78342D-07
Stage-2 Tank Top, IMU Locat.     40015     0.59762D-05  -0.26346D-04   0.22905D-04  -0.13618D-03   0.45424D-07   0.78342D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.59762D-05  -0.26346D-04   0.22905D-04
Stage-2 Tank Top, IMU Locat.     40015     0.59762D-05  -0.26346D-04   0.22905D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.17808D-04  -0.85477D-04   0.69399D-04   0.58171D-03  -0.20048D-05  -0.25872D-05
Fuel Slosh Mass Locat.             600     0.39223D-04  -0.69097D-03   0.56651D-03  -0.29530D-02  -0.15809D-04  -0.18816D-04

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.13446D-04   0.17870D-03  -0.14618D-03  -0.49134D-05  -0.53449D-04  -0.68710D-04

MODE# 24/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    358.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.54057D-02   0.13348D-01  -0.13225D-04  -0.14365D-03  -0.68734D-04  -0.20861D-02
S1 Engine No:2 +Y-Z               1152     0.23642D-02   0.13201D-01   0.85038D-04   0.27989D-04  -0.87564D-04  -0.23784D-02
S1 Engine No:3 -Y-Z               1153    -0.23500D-02   0.13201D-01  -0.51996D-04   0.27050D-04   0.92214D-04  -0.23746D-02
S1 Engine No:4 -Y-Z               1154    -0.53996D-02   0.13330D-01   0.33058D-04  -0.11917D-03   0.48389D-04  -0.20810D-02
S1 Engine No:5 -Y+Z               1155    -0.54462D-02   0.13266D-01   0.42263D-04   0.16351D-03  -0.88758D-04  -0.21022D-02
S1 Engine No:6 -Y+Z               1156    -0.23701D-02   0.13148D-01   0.98037D-04  -0.82054D-04  -0.72329D-04  -0.24083D-02
S1 Engine No:7 +Y+Z               1157     0.23976D-02   0.13151D-01  -0.12547D-03  -0.51079D-04   0.92334D-04  -0.23909D-02
S1 Engine No:8 +Y+Z               1158     0.54294D-02   0.13309D-01  -0.27134D-04   0.17520D-03   0.87070D-04  -0.20810D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.77869D-03  -0.15443D-01   0.48251D-06  -0.13403D-07  -0.16742D-06  -0.32718D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.77869D-03  -0.15443D-01   0.48251D-06  -0.13403D-07  -0.16742D-06  -0.32718D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.77869D-03  -0.15443D-01   0.48251D-06  -0.13403D-07  -0.16742D-06  -0.32718D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.77869D-03  -0.15443D-01   0.48251D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.77869D-03  -0.15443D-01   0.48251D-06

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10682D-03   0.94896D-01  -0.65697D-05   0.54850D-07   0.72575D-06   0.12431D-01
Fuel Slosh Mass Locat.             600    -0.65124D-04   0.99968D-02  -0.48513D-05  -0.47437D-06   0.33224D-06   0.17338D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.20055D-01  -0.46591D+00   0.25796D-04   0.31109D-08   0.15824D-04   0.29724D+00

MODE# 25/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    361.23       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.24060D-02  -0.66460D-04  -0.13566D-01  -0.39485D-04  -0.24325D-02  -0.77216D-04
S1 Engine No:2 +Y-Z               1152     0.55495D-02   0.28253D-05  -0.13684D-01   0.12392D-03  -0.21433D-02  -0.54114D-04
S1 Engine No:3 -Y-Z               1153     0.55649D-02   0.88490D-05  -0.13661D-01  -0.14105D-03  -0.21445D-02   0.66892D-04
S1 Engine No:4 -Y-Z               1154     0.24225D-02   0.75196D-04  -0.13541D-01   0.55007D-04  -0.24427D-02   0.77730D-04
S1 Engine No:5 -Y+Z               1155    -0.24296D-02  -0.11449D-03  -0.13542D-01   0.49561D-04  -0.24425D-02  -0.81234D-04
S1 Engine No:6 -Y+Z               1156    -0.55514D-02  -0.25220D-04  -0.13688D-01  -0.16321D-03  -0.21362D-02  -0.78642D-04
S1 Engine No:7 +Y+Z               1157    -0.55360D-02  -0.13579D-04  -0.13712D-01   0.14460D-03  -0.21330D-02   0.65669D-04
S1 Engine No:8 +Y+Z               1158    -0.24184D-02   0.81096D-04  -0.13568D-01  -0.30083D-04  -0.24290D-02   0.83494D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.97206D-07   0.11210D-05   0.12836D-01  -0.97122D-06  -0.32137D-02   0.19739D-06
Stage-2 Tank Top, IMU Locat.     40015     0.97206D-07   0.11210D-05   0.12836D-01  -0.97122D-06  -0.32137D-02   0.19739D-06
Stage-2 Tank Top, IMU Locat.     40015     0.97206D-07   0.11210D-05   0.12836D-01  -0.97122D-06  -0.32137D-02   0.19739D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.97206D-07   0.11210D-05   0.12836D-01
Stage-2 Tank Top, IMU Locat.     40015     0.97206D-07   0.11210D-05   0.12836D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.27870D-06  -0.42479D-05  -0.98555D-01   0.16618D-06   0.12601D-01  -0.67369D-06
Fuel Slosh Mass Locat.             600     0.89519D-06   0.37444D-05  -0.10637D-01  -0.35311D-06   0.17754D-02   0.14136D-06

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.10935D-05   0.26311D-04   0.46214D+00  -0.21266D-04   0.28858D+00  -0.17075D-04

MODE# 26/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    408.32       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.71209D-02   0.22771D-01  -0.58428D-03  -0.80070D-03  -0.32618D-03  -0.24407D-02
S1 Engine No:2 +Y-Z               1152     0.39557D-02   0.21149D-01   0.10424D-02  -0.95993D-03  -0.76244D-03  -0.32670D-02
S1 Engine No:3 -Y-Z               1153    -0.30329D-02   0.20980D-01   0.15150D-02   0.34950D-03   0.49178D-04  -0.38796D-02
S1 Engine No:4 -Y-Z               1154    -0.84519D-02   0.20238D-01   0.79930D-03   0.64212D-03  -0.40765D-03  -0.31831D-02
S1 Engine No:5 -Y+Z               1155    -0.94065D-02   0.18878D-01   0.71190D-03   0.44526D-03  -0.44447D-03  -0.33349D-02
S1 Engine No:6 -Y+Z               1156    -0.38737D-02   0.19503D-01  -0.28929D-03  -0.14904D-02  -0.19498D-04  -0.47074D-02
S1 Engine No:7 +Y+Z               1157     0.48442D-02   0.19693D-01  -0.23558D-02  -0.18412D-05   0.86749D-03  -0.39718D-02
S1 Engine No:8 +Y+Z               1158     0.79369D-02   0.21546D-01  -0.85833D-03   0.18146D-02   0.10384D-02  -0.24426D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.28120D-03   0.69092D-01  -0.26688D-04  -0.82334D-08   0.17242D-05   0.43306D-02
Stage-2 Tank Top, IMU Locat.     40015     0.28120D-03   0.69092D-01  -0.26688D-04  -0.82334D-08   0.17242D-05   0.43306D-02
Stage-2 Tank Top, IMU Locat.     40015     0.28120D-03   0.69092D-01  -0.26688D-04  -0.82334D-08   0.17242D-05   0.43306D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.28120D-03   0.69092D-01  -0.26688D-04
Stage-2 Tank Top, IMU Locat.     40015     0.28120D-03   0.69092D-01  -0.26688D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.41979D-04   0.13447D+00  -0.51287D-04   0.41587D-07   0.42014D-05   0.11360D-01
Fuel Slosh Mass Locat.             600    -0.96227D-04   0.25744D-01  -0.15060D-04  -0.43073D-06   0.14345D-05   0.28620D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.79985D-02   0.17001D+00  -0.71149D-04   0.82009D-09  -0.63413D-04  -0.15719D+00

MODE# 27/ 38, Frequency (rad/sec), Damping (zeta), Generalized Mass=    408.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.27146D-02   0.19297D-02  -0.20409D-01  -0.98406D-03  -0.41602D-02   0.26008D-03
S1 Engine No:2 +Y-Z               1152     0.88136D-02   0.44807D-03  -0.18987D-01  -0.80246D-03  -0.34558D-02   0.40873D-03
S1 Engine No:3 -Y-Z               1153     0.92454D-02   0.24868D-03  -0.18358D-01   0.28817D-03  -0.34829D-02  -0.27600D-04
S1 Engine No:4 -Y-Z               1154     0.31546D-02  -0.13234D-02  -0.19685D-01   0.14933D-02  -0.45348D-02  -0.22625D-03
S1 Engine No:5 -Y+Z               1155    -0.49173D-02  -0.26327D-02  -0.19954D-01  -0.60155D-03  -0.35429D-02  -0.97140D-03
S1 Engine No:6 -Y+Z               1156    -0.74696D-02  -0.55272D-03  -0.22287D-01  -0.18510D-02  -0.22732D-02  -0.99665D-03
S1 Engine No:7 +Y+Z               1157    -0.70331D-02  -0.20424D-03  -0.22927D-01   0.13297D-02  -0.22339D-02   0.61028D-03
S1 Engine No:8 +Y+Z               1158    -0.44966D-02   0.19792D-02  -0.20680D-01   0.11286D-02  -0.31550D-02   0.95335D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.17336D-07  -0.27313D-04  -0.69099D-01   0.40788D-06   0.44452D-02  -0.17058D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.17336D-07  -0.27313D-04  -0.69099D-01   0.40788D-06   0.44452D-02  -0.17058D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.17336D-07  -0.27313D-04  -0.69099D-01   0.40788D-06   0.44452D-02  -0.17058D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.17336D-07  -0.27313D-04  -0.69099D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.17336D-07  -0.27313D-04  -0.69099D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.50492D-06  -0.52807D-04  -0.13199D+00  -0.14089D-06   0.11085D-01  -0.45664D-05
Fuel Slosh Mass Locat.             600     0.18256D-05  -0.48666D-05  -0.25334D-01  -0.27744D-06   0.28158D-02  -0.78379D-06

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.31527D-05  -0.65700D-04  -0.17997D+00   0.46775D-05  -0.16126D+00   0.61062D-04

MODE# 28/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    465.66       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.23858D-01  -0.53596D-01  -0.51572D-03   0.37967D-02   0.25420D-02   0.71856D-02
S1 Engine No:2 +Y-Z               1152    -0.13068D-01  -0.50340D-01  -0.27767D-02  -0.14683D-02   0.34483D-02   0.13693D-01
S1 Engine No:3 -Y-Z               1153     0.13999D-01  -0.50315D-01   0.26338D-02  -0.17183D-02  -0.33515D-02   0.13938D-01
S1 Engine No:4 -Y-Z               1154     0.24921D-01  -0.53552D-01   0.47608D-03   0.40530D-02  -0.29635D-02   0.75194D-02
S1 Engine No:5 -Y+Z               1155     0.24444D-01  -0.54036D-01  -0.22636D-03  -0.36588D-02   0.24650D-02   0.72612D-02
S1 Engine No:6 -Y+Z               1156     0.13760D-01  -0.50699D-01  -0.26537D-02   0.11076D-02   0.34901D-02   0.13435D-01
S1 Engine No:7 +Y+Z               1157    -0.12796D-01  -0.50640D-01   0.20921D-02   0.16092D-02  -0.30556D-02   0.13729D-01
S1 Engine No:8 +Y+Z               1158    -0.24020D-01  -0.53564D-01   0.16554D-03  -0.37189D-02  -0.27289D-02   0.75767D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.41494D-04  -0.20260D-02  -0.31814D-05   0.18030D-07  -0.96581D-05   0.59324D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.41494D-04  -0.20260D-02  -0.31814D-05   0.18030D-07  -0.96581D-05   0.59324D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.41494D-04  -0.20260D-02  -0.31814D-05   0.18030D-07  -0.96581D-05   0.59324D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.41494D-04  -0.20260D-02  -0.31814D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.41494D-04  -0.20260D-02  -0.31814D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.25379D-03  -0.59848D-01  -0.98682D-04  -0.75216D-07  -0.17615D-05   0.97645D-03
Fuel Slosh Mass Locat.             600     0.91612D-03  -0.73390D-01  -0.12192D-03   0.86012D-06   0.75000D-05  -0.47872D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.25850D-02  -0.62982D-01  -0.10605D-03  -0.97552D-09  -0.12310D-03   0.74585D-01

MODE# 29/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    465.78       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13826D-01   0.29206D-02   0.50298D-01   0.15982D-02   0.13985D-01   0.37962D-02
S1 Engine No:2 +Y-Z               1152    -0.24100D-01   0.37674D-03   0.53932D-01  -0.42733D-02   0.69545D-02   0.29986D-02
S1 Engine No:3 -Y-Z               1153    -0.24022D-01  -0.40997D-03   0.54009D-01   0.41879D-02   0.69934D-02  -0.29218D-02
S1 Engine No:4 -Y-Z               1154    -0.13651D-01  -0.29317D-02   0.50428D-01  -0.15282D-02   0.13919D-01  -0.37134D-02
S1 Engine No:5 -Y+Z               1155     0.13643D-01   0.26246D-02   0.50409D-01  -0.16748D-02   0.14005D-01   0.36805D-02
S1 Engine No:6 -Y+Z               1156     0.24105D-01   0.25235D-03   0.53863D-01   0.41534D-02   0.70072D-02   0.29360D-02
S1 Engine No:7 +Y+Z               1157     0.24170D-01  -0.52897D-03   0.53739D-01  -0.42632D-02   0.70246D-02  -0.30006D-02
S1 Engine No:8 +Y+Z               1158     0.13647D-01  -0.28731D-02   0.50274D-01   0.17936D-02   0.14105D-01  -0.36475D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.72165D-06  -0.39752D-05   0.23056D-02  -0.21397D-06   0.59082D-02   0.98838D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.72165D-06  -0.39752D-05   0.23056D-02  -0.21397D-06   0.59082D-02   0.98838D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.72165D-06  -0.39752D-05   0.23056D-02  -0.21397D-06   0.59082D-02   0.98838D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.72165D-06  -0.39752D-05   0.23056D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.72165D-06  -0.39752D-05   0.23056D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.34431D-05  -0.99251D-04   0.60093D-01   0.12150D-06   0.96426D-03   0.14389D-05
Fuel Slosh Mass Locat.             600    -0.10349D-04  -0.11854D-03   0.72767D-01   0.44830D-06  -0.47467D-02  -0.80448D-05

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.39426D-05  -0.10488D-03   0.64869D-01   0.48487D-07   0.75436D-01   0.12446D-03

MODE# 30/ 55, Frequency (rad/sec), Damping (zeta), Generalized Mass=    483.78       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.38046D-01   0.76329D-01  -0.33913D-03   0.13494D-01   0.10217D-01  -0.24655D-01
S1 Engine No:2 +Y-Z               1152     0.24902D-02   0.87417D-01  -0.85842D-02  -0.55088D-02   0.12780D-01  -0.39458D-02
S1 Engine No:3 -Y-Z               1153    -0.67422D-02   0.87441D-01   0.10309D-01  -0.56017D-02  -0.12068D-01  -0.40758D-02
S1 Engine No:4 -Y-Z               1154    -0.41654D-01   0.76553D-01   0.22460D-02   0.13362D-01  -0.95932D-02  -0.24994D-01
S1 Engine No:5 -Y+Z               1155    -0.40823D-01   0.77188D-01  -0.10797D-02  -0.13978D-01   0.10433D-01  -0.25014D-01
S1 Engine No:6 -Y+Z               1156    -0.53498D-02   0.88264D-01  -0.91016D-02   0.62741D-02   0.12566D-01  -0.34562D-02
S1 Engine No:7 +Y+Z               1157     0.26978D-02   0.88225D-01   0.11343D-01   0.59760D-02  -0.12809D-01  -0.34732D-02
S1 Engine No:8 +Y+Z               1158     0.38054D-01   0.76856D-01   0.29935D-02  -0.14017D-01  -0.10178D-01  -0.24830D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.38680D-03  -0.27970D-01  -0.31972D-03  -0.47388D-07  -0.43792D-04   0.38442D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.38680D-03  -0.27970D-01  -0.31972D-03  -0.47388D-07  -0.43792D-04   0.38442D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.38680D-03  -0.27970D-01  -0.31972D-03  -0.47388D-07  -0.43792D-04   0.38442D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.38680D-03  -0.27970D-01  -0.31972D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.38680D-03  -0.27970D-01  -0.31972D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.19288D-02   0.15760D-01   0.17548D-03   0.18281D-06   0.87565D-04  -0.77016D-02
Fuel Slosh Mass Locat.             600    -0.53532D-02   0.10307D+00   0.11747D-02  -0.20845D-05  -0.79100D-04   0.70141D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.15398D-02  -0.27115D-01  -0.32182D-03   0.53934D-09  -0.49903D-03   0.43259D-01

MODE# 31/ 56, Frequency (rad/sec), Damping (zeta), Generalized Mass=    484.11       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.56814D-02   0.10012D-01  -0.89212D-01   0.57647D-02  -0.44141D-02   0.11650D-01
S1 Engine No:2 +Y-Z               1152     0.40261D-01   0.24216D-02  -0.78808D-01  -0.13082D-01  -0.24481D-01   0.95918D-02
S1 Engine No:3 -Y-Z               1153     0.39957D-01  -0.78957D-03  -0.78878D-01   0.13225D-01  -0.24786D-01  -0.98742D-02
S1 Engine No:4 -Y-Z               1154     0.45310D-02  -0.86203D-02  -0.89553D-01  -0.57176D-02  -0.44128D-02  -0.12296D-01
S1 Engine No:5 -Y+Z               1155    -0.53177D-02   0.10585D-01  -0.89559D-01  -0.57701D-02  -0.43496D-02   0.11850D-01
S1 Engine No:6 -Y+Z               1156    -0.40161D-01   0.27815D-02  -0.78891D-01   0.13354D-01  -0.24534D-01   0.97633D-02
S1 Engine No:7 +Y+Z               1157    -0.40296D-01  -0.42769D-03  -0.78350D-01  -0.12938D-01  -0.24834D-01  -0.96218D-02
S1 Engine No:8 +Y+Z               1158    -0.46694D-02  -0.85204D-02  -0.89140D-01   0.51780D-02  -0.48160D-02  -0.12373D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01  -0.13799D-06   0.38954D-02   0.44483D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01  -0.13799D-06   0.38954D-02   0.44483D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01  -0.13799D-06   0.38954D-02   0.44483D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.12489D-05  -0.32727D-03   0.28759D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.34315D-05   0.19758D-03  -0.16952D-01   0.16406D-06  -0.78913D-02  -0.90274D-04
Fuel Slosh Mass Locat.             600    -0.84619D-05   0.11823D-02  -0.10369D+00  -0.70871D-06   0.70250D-02   0.81496D-04

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.19605D-04  -0.30963D-03   0.28244D-01   0.29117D-06   0.44068D-01   0.49698D-03

MODE# 32/ 57, Frequency (rad/sec), Damping (zeta), Generalized Mass=    492.66       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.13885D-01   0.98884D-02  -0.11631D-04   0.84175D-03   0.20712D-03  -0.36028D-02
S1 Engine No:2 +Y-Z               1152     0.10104D-01   0.10540D-01  -0.52880D-03  -0.36486D-03  -0.18400D-03  -0.18149D-02
S1 Engine No:3 -Y-Z               1153     0.72800D-02   0.10497D-01   0.64241D-03  -0.33072D-03  -0.16972D-02  -0.96530D-03
S1 Engine No:4 -Y-Z               1154     0.35647D-02   0.98381D-02   0.16192D-03   0.78724D-03  -0.99583D-03  -0.16974D-02
S1 Engine No:5 -Y+Z               1155     0.36636D-02   0.99171D-02  -0.17716D-04  -0.86503D-03   0.10986D-02  -0.16918D-02
S1 Engine No:6 -Y+Z               1156     0.74357D-02   0.10604D-01  -0.49901D-03   0.40591D-03   0.17508D-02  -0.88609D-03
S1 Engine No:7 +Y+Z               1157     0.10133D-01   0.10642D-01   0.81706D-03   0.38567D-03   0.16686D-03  -0.17760D-02
S1 Engine No:8 +Y+Z               1158     0.13908D-01   0.99344D-02   0.25808D-03  -0.89610D-03  -0.18024D-03  -0.36428D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04   0.17743D-06  -0.61448D-05   0.63956D-03
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04   0.17743D-06  -0.61448D-05   0.63956D-03
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04   0.17743D-06  -0.61448D-05   0.63956D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04
Stage-2 Tank Top, IMU Locat.     40015     0.21692D-02  -0.57506D-02  -0.55333D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.12611D-01   0.85388D-02   0.81900D-04  -0.62132D-06   0.15614D-04  -0.16252D-02
Fuel Slosh Mass Locat.             600     0.33931D-01   0.77520D-02   0.75540D-04   0.68892D-05  -0.27342D-05   0.32128D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.15137D-02  -0.29552D-02  -0.28985D-04  -0.15269D-07  -0.54664D-04   0.56609D-02

MODE# 33/ 58, Frequency (rad/sec), Damping (zeta), Generalized Mass=    515.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.35969D-01  -0.14007D+00  -0.77955D-01  -0.48260D-02  -0.12668D-01   0.20172D-01
S1 Engine No:2 +Y-Z               1152     0.10148D-01  -0.14707D+00  -0.71499D-01  -0.40314D-03  -0.16549D-01   0.14050D-01
S1 Engine No:3 -Y-Z               1153     0.33527D-01  -0.14798D+00  -0.80561D-01   0.60634D-02   0.49602D-04   0.68711D-02
S1 Engine No:4 -Y-Z               1154     0.47944D-01  -0.14493D+00  -0.79252D-01  -0.78376D-02   0.13018D-02   0.11770D-01
S1 Engine No:5 -Y+Z               1155     0.35019D-01  -0.14056D+00  -0.77434D-01   0.54156D-02  -0.13070D-01   0.20452D-01
S1 Engine No:6 -Y+Z               1156    -0.11346D-01  -0.14782D+00  -0.70963D-01  -0.36656D-03  -0.17014D-01   0.13202D-01
S1 Engine No:7 +Y+Z               1157    -0.33439D-01  -0.14865D+00  -0.81545D-01  -0.61714D-02   0.71434D-03   0.65328D-02
S1 Engine No:8 +Y+Z               1158    -0.48518D-01  -0.14503D+00  -0.79744D-01   0.81565D-02   0.13423D-02   0.12221D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02   0.37814D-08  -0.53273D-03   0.10004D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02   0.37814D-08  -0.53273D-03   0.10004D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02   0.37814D-08  -0.53273D-03   0.10004D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.30009D-03  -0.10289D-01  -0.54921D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.16109D-02   0.33624D-01   0.17914D-01  -0.13241D-07   0.15137D-02  -0.28398D-02
Fuel Slosh Mass Locat.             600    -0.36034D-02  -0.87273D-01  -0.46475D-01   0.14495D-06   0.39739D-02  -0.74431D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.49128D-04   0.58662D-03   0.26884D-03   0.49566D-08  -0.12523D-02   0.23226D-02

MODE# 34/ 59, Frequency (rad/sec), Damping (zeta), Generalized Mass=    515.91       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.34259D-01   0.79832D-01  -0.14868D+00   0.64283D-02  -0.66716D-02  -0.37019D-03
S1 Engine No:2 +Y-Z               1152     0.48138D-01   0.78913D-01  -0.14599D+00  -0.76684D-02  -0.11376D-01   0.13518D-02
S1 Engine No:3 -Y-Z               1153     0.35570D-01   0.77153D-01  -0.14149D+00   0.50095D-02  -0.20299D-01  -0.12622D-01
S1 Engine No:4 -Y-Z               1154    -0.10506D-01   0.70852D-01  -0.14846D+00  -0.30233D-04  -0.13768D-01  -0.16711D-01
S1 Engine No:5 -Y+Z               1155    -0.33214D-01   0.80926D-01  -0.14935D+00  -0.64676D-02  -0.65472D-02  -0.71041D-04
S1 Engine No:6 -Y+Z               1156    -0.47466D-01   0.79706D-01  -0.14625D+00   0.82651D-02  -0.11242D-01   0.18683D-02
S1 Engine No:7 +Y+Z               1157    -0.36074D-01   0.77946D-01  -0.14027D+00  -0.44293D-02  -0.20645D-01  -0.11992D-01
