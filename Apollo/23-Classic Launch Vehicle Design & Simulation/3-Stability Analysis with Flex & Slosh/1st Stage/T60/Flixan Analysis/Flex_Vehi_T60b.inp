BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=60 sec
! This batch set creates dynamic models for Control Analysis at T=60 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
! --------------   Create Vehicle, TVC and Actuator Models  ------------
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=60.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=60.0 sec 
Actuator Model   : Stage-1 Linear Actuator
System Connection: System of 8 TVC Actuators
!
! --------------   Build the Flight Control System  ---------------------
Transf-Function  : Integrator
Transf-Function  : Alpha Estimator
Transf-Function  : Beta Estimator
Transf-Function  : Low Pass Filters
System Connection: Flight Control System 
!
!  -------------   Create Plant Models  ---------------------------------
System Connection: Plant Model at T=60 sec, Vehicle/ Actuators
System Connection: Closed-Loop System
System Connection: Open-Loop System
System Connection: Roll Loop Opened, Others Closed
System Connection: Pitch Loop Opened, Others Closed
System Connection: Yaw Loop Opened, Others Closed
!
!  -------------   Export to Matlab  -----------------------------------
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=60.0 sec            
To Matlab Format : Plant Model at T=60 sec, Vehicle/ Actuators
To Matlab Format : Mixing Logic for First Stage Model, at T=60.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
To Matlab Format : Flight Control System
To Matlab Format : Closed-Loop System
To Matlab Format : Open-Loop System
To Matlab Format : Roll Loop Opened, Others Closed
To Matlab Format : Pitch Loop Opened, Others Closed
To Matlab Format : Yaw Loop Opened, Others Closed
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=60.0 sec                                       
! This is a Launch Vehicle Control Analysis Model at t=60 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 60% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.05 .
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   3940.97       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   29031.4      0.260692E+07  0.260596E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   57.4788       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.76300       816.210       416.620       19772.5    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   22.20         52.9          0.0          -0.2882    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.479        -0.0          -0.020         0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          74.65         0.00000      -0.0          -0.592         0.0
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.000        90.00                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.415        7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.531702      0.00760        0.000335      0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0          -0.07455        0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.03541      -0.07455        0.00000       0.00000       0.00000       0.00000     -0.467511E-04
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.00000       0.00000        0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.1372       -0.286450       0.00000       0.00000       0.00000     -0.260394E-03   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0           0.286450       0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945       -1.0332     
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332       -2.4945 
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332       -2.4945
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945       -1.0332 
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945        1.0332
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332        2.4945
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332        2.4945
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   24160.0       24160.0 
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945        1.0332 

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438    0.000      0.000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438    0.000      0.000    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438    0.000      0.000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000       

Number of Slosh Modes                                                                    :  2
LOX Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   565.1   3.11   3.11   0.018  0.018  62.37   0.0  0.0  
LH2 Mass (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft) :   194.6   3.11   3.11   0.01   0.01   32.92   0.0  0.0 

Number of Bending Modes                                                                  : 20
First Stage Flex Modes at 70% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=60.0 sec 
! Thrust Vector Control Matrix at t=60 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=60.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
System of 8 TVC Actuators
! Combination of 8 TVC Actuators in Parallel
Titles of Systems to be Combined
Title 1 Stage-1 Linear Actuator 
Title 2 Stage-1 Linear Actuator 
Title 3 Stage-1 Linear Actuator 
Title 4 Stage-1 Linear Actuator 
Title 5 Stage-1 Linear Actuator 
Title 6 Stage-1 Linear Actuator 
Title 7 Stage-1 Linear Actuator 
Title 8 Stage-1 Linear Actuator 
SYSTEM INPUTS TO SUBSYSTEM  1                                                           Engine # 1
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                Command Input
System Input  9 to Subsystem  1, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                           Engine # 2
System Input  2 to Subsystem  2, Input  1, Gain= 1.00000                                Command Input
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                           Engine # 3
System Input  3 to Subsystem  3, Input  1, Gain= 1.00000                                Command Input
System Input 11 to Subsystem  3, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                           Engine # 4
System Input  4 to Subsystem  4, Input  1, Gain= 1.00000                                Command Input
System Input 12 to Subsystem  4, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                           Engine # 5
System Input  5 to Subsystem  5, Input  1, Gain= 1.00000                                Command Input
System Input 13 to Subsystem  5, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  6                                                           Engine # 6
System Input  6 to Subsystem  6, Input  1, Gain= 1.00000                                Command Input
System Input 14 to Subsystem  6, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  7                                                           Engine # 7
System Input  7 to Subsystem  7, Input  1, Gain= 1.00000                                Command Input
System Input 15 to Subsystem  7, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  8                                                           Engine # 8
System Input  8 to Subsystem  8, Input  1, Gain= 1.00000                                Command Input
System Input 16 to Subsystem  8, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                        Engine # 1
System Output  1 from Subsystem  1, Output  1, Gain= 1.00000                            Deflection
System Output  9 from Subsystem  1, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                        Engine # 2
System Output  2 from Subsystem  2, Output  1, Gain= 1.00000                            Deflection
System Output 10 from Subsystem  2, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                        Engine # 3
System Output  3 from Subsystem  3, Output  1, Gain= 1.00000                            Deflection
System Output 11 from Subsystem  3, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                        Engine # 4
System Output  4 from Subsystem  4, Output  1, Gain= 1.00000                            Deflection
System Output 12 from Subsystem  4, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5                                                        Engine # 5
System Output  5 from Subsystem  5, Output  1, Gain= 1.00000                            Deflection
System Output 13 from Subsystem  5, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  6                                                        Engine # 6
System Output  6 from Subsystem  6, Output  1, Gain= 1.00000                            Deflection
System Output 14 from Subsystem  6, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  7                                                        Engine # 7
System Output  7 from Subsystem  7, Output  1, Gain= 1.00000                            Deflection
System Output 15 from Subsystem  7, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  8                                                        Engine # 8
System Output  8 from Subsystem  8, Output  1, Gain= 1.00000                            Deflection
System Output 16 from Subsystem  8, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
Definitions of Inputs  =  16
Engine # 1 delta command (rad)   
Engine # 2 delta command (rad)                                                              
Engine # 3 delta command (rad)                                                              
Engine # 4 delta command (rad)                                                              
Engine # 5 delta command (rad)                                                              
Engine # 6 delta command (rad)                                                              
Engine # 7 delta command (rad)                                                              
Engine # 8 delta command (rad)                                                              
Engine # 1 Load-Torque (ft-lb)    
Engine # 2 Load-Torque (ft-lb)    
Engine # 3 Load-Torque (ft-lb)    
Engine # 4 Load-Torque (ft-lb)    
Engine # 5 Load-Torque (ft-lb)    
Engine # 6 Load-Torque (ft-lb)    
Engine # 7 Load-Torque (ft-lb)    
Engine # 8 Load-Torque (ft-lb)    
 
Definitions of Outputs =  16
Engine # 1 deflection (rad)   
Engine # 2 deflection (rad)   
Engine # 3 deflection (rad)   
Engine # 4 deflection (rad)   
Engine # 5 deflection (rad)   
Engine # 6 deflection (rad)   
Engine # 7 deflection (rad)   
Engine # 8 deflection (rad)   
Engine # 1 accelerat. (rad/sec^2)   
Engine # 2 accelerat. (rad/sec^2)   
Engine # 3 accelerat. (rad/sec^2)   
Engine # 4 accelerat. (rad/sec^2)   
Engine # 5 accelerat. (rad/sec^2)   
Engine # 6 accelerat. (rad/sec^2)   
Engine # 7 accelerat. (rad/sec^2)   
Engine # 8 accelerat. (rad/sec^2)   
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Plant Model at T=60 sec, Vehicle/ Actuators
! Combines the Vehicle with the 8 Pitch and 8 Yaw Actuators
!
Titles of Systems to be Combined
Title 1 Launch Vehicle First Stage Analysis Model, T=60.0 sec                                                    
Title 2 System of 8 TVC Actuators              
Title 3 System of 8 TVC Actuators           
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   To Pitch Actuators (1-8)
System Input  1 to Subsystem  2, Input  1, Gain= 1.00000            
System Input  2 to Subsystem  2, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  2, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  2, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  2, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  2, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  2, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  2, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   To Yaw Actuators (1-8)
System Input  9 to Subsystem  3, Input  1, Gain= 1.00000            
System Input 10 to Subsystem  3, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  3, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  3, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  3, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  3, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  3, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  3, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  1                                                                  
System Input 17 to Subsystem  1, Input 33, Gain= 1.0                                            Wind-Gust
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                         Pitch Actuat to Vehicle 
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                    delta_y1  Pitch Engine Deflects  
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                    delta_y2
Subsystem  2, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                    delta_y3
Subsystem  2, Output  4 to Subsystem  1, Input  4, Gain= 1.0                                    delta_y4
Subsystem  2, Output  5 to Subsystem  1, Input  5, Gain= 1.0                                    delta_y5
Subsystem  2, Output  6 to Subsystem  1, Input  6, Gain= 1.0                                    delta_y6
Subsystem  2, Output  7 to Subsystem  1, Input  7, Gain= 1.0                                    delta_y7
Subsystem  2, Output  8 to Subsystem  1, Input  8, Gain= 1.0                                    delta_y8
Subsystem  2, Output  9 to Subsystem  1, Input  9, Gain= 1.0                                    dy1_dd    Engine Accels
Subsystem  2, Output 10 to Subsystem  1, Input 10, Gain= 1.0                                    dy2_dd
Subsystem  2, Output 11 to Subsystem  1, Input 11, Gain= 1.0                                    dy3_dd
Subsystem  2, Output 12 to Subsystem  1, Input 12, Gain= 1.0                                    dy4_dd
Subsystem  2, Output 13 to Subsystem  1, Input 13, Gain= 1.0                                    dy5_dd
Subsystem  2, Output 14 to Subsystem  1, Input 14, Gain= 1.0                                    dy6_dd
Subsystem  2, Output 15 to Subsystem  1, Input 15, Gain= 1.0                                    dy7_dd
Subsystem  2, Output 16 to Subsystem  1, Input 16, Gain= 1.0                                    dy8_dd
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                                                         Yaw Actuat to Vehicle 
Subsystem  3, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                    delta_z1  Yaw Engine Deflects
Subsystem  3, Output  2 to Subsystem  1, Input 18, Gain= 1.0                                    delta_z2
Subsystem  3, Output  3 to Subsystem  1, Input 19, Gain= 1.0                                    delta_z3
Subsystem  3, Output  4 to Subsystem  1, Input 20, Gain= 1.0                                    delta_z4
Subsystem  3, Output  5 to Subsystem  1, Input 21, Gain= 1.0                                    delta_z5
Subsystem  3, Output  6 to Subsystem  1, Input 22, Gain= 1.0                                    delta_z6
Subsystem  3, Output  7 to Subsystem  1, Input 23, Gain= 1.0                                    delta_z7
Subsystem  3, Output  8 to Subsystem  1, Input 24, Gain= 1.0                                    delta_z8
Subsystem  3, Output  9 to Subsystem  1, Input 25, Gain= 1.0                                    dz1_dd    Yaw Engine Accels
Subsystem  3, Output 10 to Subsystem  1, Input 26, Gain= 1.0                                    dz2_dd
Subsystem  3, Output 11 to Subsystem  1, Input 27, Gain= 1.0                                    dz3_dd
Subsystem  3, Output 12 to Subsystem  1, Input 28, Gain= 1.0                                    dz4_dd
Subsystem  3, Output 13 to Subsystem  1, Input 29, Gain= 1.0                                    dz5_dd
Subsystem  3, Output 14 to Subsystem  1, Input 30, Gain= 1.0                                    dz6_dd
Subsystem  3, Output 15 to Subsystem  1, Input 31, Gain= 1.0                                    dz7_dd
Subsystem  3, Output 16 to Subsystem  1, Input 32, Gain= 1.0                                    dz8_dd
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                         Load-Torq TLY to Pitch Actuat 
Subsystem  1, Output 17 to Subsystem  2, Input  9, Gain= 1.0                                    TL_y1
Subsystem  1, Output 18 to Subsystem  2, Input 10, Gain= 1.0                                    TL_y2
Subsystem  1, Output 19 to Subsystem  2, Input 11, Gain= 1.0                                    TL_y3
Subsystem  1, Output 20 to Subsystem  2, Input 12, Gain= 1.0                                    TL_y4
Subsystem  1, Output 21 to Subsystem  2, Input 13, Gain= 1.0                                    TL_y5
Subsystem  1, Output 22 to Subsystem  2, Input 14, Gain= 1.0                                    TL_y6
Subsystem  1, Output 23 to Subsystem  2, Input 15, Gain= 1.0                                    TL_y7
Subsystem  1, Output 24 to Subsystem  2, Input 16, Gain= 1.0                                    TL_y8
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Load-Torq TLZ to Yaw Actuators
Subsystem  1, Output 25 to Subsystem  3, Input  9, Gain= 1.0                                    TL_z1
Subsystem  1, Output 26 to Subsystem  3, Input 10, Gain= 1.0                                    TL_z2
Subsystem  1, Output 27 to Subsystem  3, Input 11, Gain= 1.0                                    TL_z3
Subsystem  1, Output 28 to Subsystem  3, Input 12, Gain= 1.0                                    TL_z4
Subsystem  1, Output 29 to Subsystem  3, Input 13, Gain= 1.0                                    TL_z5
Subsystem  1, Output 30 to Subsystem  3, Input 14, Gain= 1.0                                    TL_z6
Subsystem  1, Output 31 to Subsystem  3, Input 15, Gain= 1.0                                    TL_z7
Subsystem  1, Output 32 to Subsystem  3, Input 16, Gain= 1.0                                    TL_z8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                Vehicle Outputs
Via Matrix +I16                                                                     
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                Pitch Gimbal Deflects
System Output 17 from Subsystem  2, Output  1, Gain= 1.0                                        dy-1
System Output 18 from Subsystem  2, Output  2, Gain= 1.0                                        dy-2
System Output 19 from Subsystem  2, Output  3, Gain= 1.0                                        dy-3
System Output 20 from Subsystem  2, Output  4, Gain= 1.0                                        dy-4
System Output 21 from Subsystem  2, Output  5, Gain= 1.0                                        dy-5
System Output 22 from Subsystem  2, Output  6, Gain= 1.0                                        dy-6
System Output 23 from Subsystem  2, Output  7, Gain= 1.0                                        dy-7
System Output 24 from Subsystem  2, Output  8, Gain= 1.0                                        dy-8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                Yaw Gimbal Deflects
System Output 25 from Subsystem  3, Output  1, Gain= 1.0                                        dz-1
System Output 26 from Subsystem  3, Output  2, Gain= 1.0                                        dz-2
System Output 27 from Subsystem  3, Output  3, Gain= 1.0                                        dz-3
System Output 28 from Subsystem  3, Output  4, Gain= 1.0                                        dz-4
System Output 29 from Subsystem  3, Output  5, Gain= 1.0                                        dz-5
System Output 30 from Subsystem  3, Output  6, Gain= 1.0                                        dz-6
System Output 31 from Subsystem  3, Output  7, Gain= 1.0                                        dz-7
System Output 32 from Subsystem  3, Output  8, Gain= 1.0                                        dz-8
..............................................................................
Definitions of Inputs  =  17
Engine Pitch Deflect Comd delta y_1 (rad)   
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)   
Wind-Gust Velocity (ft/sec)
 
Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Alpha Estimator
Continuous
TF. Block #  1 Nz-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Alfa Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at 4.38 (rad)                          Order of Numer, Denom=  2  2
Numer 1.0         0.069       18.49
Denom 1.0         1.376       18.49
......................................................
Block #, from Input #, Gain
 2       1    -24160.0                                           Eng #1 Dy
 2       2    -24160.0                                           Eng #2 Dy
 2       3    -24160.0                                           Eng #3 Dy
 2       4    -24160.0                                           Eng #4 Dy
 2       5    -24160.0                                           Eng #5 Dy
 2       6    -24160.0                                           Eng #6 Dy
 2       7    -24160.0                                           Eng #7 Dy
 2       8    -24160.0                                           Eng #8 Dy
 1       9     19.0                                              Pitch Rate q
 2      10    -3941.0                                            Zdd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    -3941.0                                            Vehi Mass
 2       3    -1380.0                                            Qbar.Sref.Cza
 3       2     0.001                                             Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (deg2rad)
............................
Definitions of Inputs  =  10
Engine # 1 DY Deflection in (rad)
Engine # 2 DY Deflection in (rad)
Engine # 3 DY Deflection in (rad)
Engine # 4 DY Deflection in (rad)
Engine # 5 DY Deflection in (rad)
Engine # 6 DY Deflection in (rad)
Engine # 7 DY Deflection in (rad)
Engine # 8 DY Deflection in (rad)
Vehicle Pitch Rate      (rad/sec)                                            
Normal  Accelerat. Nz (ft/sec^2)                                                
 
Definitions of Outputs =   1
Alpha Estimate in (rad)
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Beta Estimator
Continuous
TF. Block #  1 Ny-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Beta Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at 4.38 (rad)                          Order of Numer, Denom=  2  2
Numer 1.0         0.069       18.49
Denom 1.0         1.376       18.49
......................................................
Block #, from Input #, Gain
 2       1     24160.0                                           Eng #1 Dz
 2       2     24160.0                                           Eng #2 Dz
 2       3     24160.0                                           Eng #3 Dz
 2       4     24160.0                                           Eng #4 Dz
 2       5     24160.0                                           Eng #5 Dz
 2       6     24160.0                                           Eng #6 Dz
 2       7     24160.0                                           Eng #7 Dz
 2       8     24160.0                                           Eng #8 Dz
 1       9     19.0                                              Yaw Rate r
 2      10    -3941.0                                            Ydd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    +3941.0                                            Vehi Mass
 2       3    -1380.0                                            Qbar.Sref.Cyb
 3       2     0.001                                             Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (deg2rad)
............................
Definitions of Inputs  =  10
Engine # 1 DZ Deflection in (rad)
Engine # 2 DZ Deflection in (rad)
Engine # 3 DZ Deflection in (rad)
Engine # 4 DZ Deflection in (rad)
Engine # 5 DZ Deflection in (rad)
Engine # 6 DZ Deflection in (rad)
Engine # 7 DZ Deflection in (rad)
Engine # 8 DZ Deflection in (rad)
Vehicle Yaw Rate      (rad/sec)                                            
Lateral Accelerat. Ny (ft/sec^2)                                                
 
Definitions of Outputs =   1
Beta Estimate in (rad)
---------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Integrator
Continuous
TF. Block #  1    1/s                                            Order of Numer, Denom=  0  1
Numer 0.0         1.0      
Denom 1.0         0.0      
......................................................
Block #, from Input #, Gain
  1  1    1.0                             
...........................
Outpt #, from Block #, Gain
  1  1    1.0
...........................
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Low Pass Filters
Continuous
TF. Block #  1 Roll Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         900.0
Denom 1.0         39.0        900.0
TF. Block #  2 Ptch Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         361.0
Denom 1.0         25.0        361.0
TF. Block #  3 Yaw Low-Pass                                      Order of Numer, Denom=  0  2
Numer 0.0         0.0         361.0
Denom 1.0         25.0        361.0
TF. Block #  4 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  5 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  6 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
......................................................
Block #, from Input #, Gain
 1       1        1.0                                            
 2       2        1.0                                            
 3       3        1.0                                            
...........................
Block #, from Block #, Gain
 4       1        1.0                                 
 5       2        1.0                                 
 6       3        1.0                                 
............................
Outpt #, from Block #, Gain
 1       4        1.0                                            DP_TVC
 2       5        1.0                                            DQ_TVC
 3       6        1.0                                            DR_TVC
............................
Definitions of Inputs  =   3
Roll   Filter Input
Pitch  Filter Input
Yaw    Filter Input
 
Definitions of Outputs =   3
Roll   Filter Output DP_tvc
Pitch  Filter Output DQ_tvc
Yaw    Filter Output DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Flight Control System
! Combine the Filters, Gains and Alpha/Beta Estimators
!
Titles of Systems to be Combined
Title 1 Alpha Estimator
Title 2 Beta Estimator
Title 3 Low Pass Filters
Title 4 Integrator
Title 5 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                                   to Alfa Estimator
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                        Pitch Gimbal Deflects DY (1-8)
System Input  2 to Subsystem  1, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  1, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  1, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  1, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  1, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  1, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  1, Input  8, Gain= 1.00000            
System Input 21 to Subsystem  1, Input  9, Gain= 1.00000                                        Pitch Rate Q
System Input 23 to Subsystem  1, Input 10, Gain= 1.00000                                        NZ Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   to Beta Estimator
System Input  9 to Subsystem  2, Input  1, Gain= 1.00000                                        Yaw Gimbal Deflects DZ (1-8)
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  2, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  2, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  2, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  2, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  2, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  2, Input  8, Gain= 1.00000            
System Input 22 to Subsystem  2, Input  9, Gain= 1.00000                                        Yaw Rate R
System Input 24 to Subsystem  2, Input 10, Gain= 1.00000                                        NY Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   to Low-Pass Filters 
System Input 17 to Subsystem  3, Input  1, Gain= 2.5                                            KL_phi
System Input 18 to Subsystem  3, Input  2, Gain= 3.0                                            KM_theta
System Input 19 to Subsystem  3, Input  3, Gain= 3.0                                            KN_psi
System Input 20 to Subsystem  3, Input  1, Gain= 2.2                                            KL_p
System Input 21 to Subsystem  3, Input  2, Gain= 2.6                                            KM_q
System Input 22 to Subsystem  3, Input  3, Gain= 2.6                                            KN_r
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Alfa Estim to Filters
Subsystem  1, Output  1 to Subsystem  3, Input  2, Gain= 0.84                                   KM_alfa
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                                         Beta Estim to Filters
Subsystem  2, Output  1 to Subsystem  3, Input  3, Gain= -0.84                                  KN_beta
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  4                                                         Alfa Estim to Integrator
Subsystem  1, Output  1 to Subsystem  4, Input  1, Gain= 1.0                                    alfin
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  5                                                         Beta Estim to Integrator
Subsystem  2, Output  1 to Subsystem  5, Input  1, Gain= 1.0                                    betin
..............................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  3                                                         alfin to Low-Pass
Subsystem  4, Output  1 to Subsystem  3, Input  2, Gain= -0.04                                  KM_alfint
..............................................................................
SUBSYSTEM NO  5 GOES TO SUBSYSTEM NO  3                                                         alfin to Low-Pass
Subsystem  5, Output  1 to Subsystem  3, Input  3, Gain=  0.04                                  KN_betint
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                from Low-Pass Filters 
System Output  1 from Subsystem  3, Output  1, Gain= -1.0                                       DP_tvc
System Output  2 from Subsystem  3, Output  2, Gain= -1.0                                       DQ_tvc
System Output  3 from Subsystem  3, Output  3, Gain= -1.0                                       DR_tvc
..............................................................................
Definitions of Inputs  =  24
Engine Pitch Deflect Comd delta y_1 (rad)  
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)  
Roll  Attitude Error (rad)                  
Pitch Attitude Error (rad)
Yaw   Attitude Error (rad)
Roll  Rate (rad/sec)                        
Pitch Rate (rad/sec)
Yaw   Rate (rad/sec)
Normal  Acceleration NZ (ft/sec^2)         
Lateral Acceleration NY (ft/sec^2)         
 
Definitions of Outputs =   3
Roll  FCS Demand DP_tvc
Pitch FCS Demand DQ_tvc
Yaw   FCS Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Closed-Loop System
! Combines the Plant Model with the Flight Control System in
! Closed-Loop form
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=60 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
System Input  1 to Subsystem  1, Input 17, Gain= -1.0                                                      Roll Command
System Input  2 to Subsystem  1, Input 18, Gain= -1.0                                                      Ptch Command
System Input  3 to Subsystem  1, Input 19, Gain= -1.0                                                      Yaw  Command
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehi
System Input  4 to Subsystem  2, Input 17, Gain=  1.0                                                      Wind Gust
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    FCS
Via Matrix +TVC                                                                     
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                                    FCS to Vehi
Via Matrix +TVC                                                                                            DY(8), DZ(8)                                                                     
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                           Vehicle Outputs
Via Matrix +I32                                                                     
..............................................................................
Definitions of Inputs  =   4
Roll  Attitude Command (rad)  
Pitch Attitude Command (rad)  
Yaw   Attitude Command (rad)  
Wind-Gust Velocity (feet/sec)

Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Open-Loop System
! Combines the Plant Model with the Flight Control System in
! Open-Loop config
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=60 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehicle
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           Vehicle Outputs
Via Matrix +I03                                                                     
..............................................................................
Definitions of Inputs  =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc

Definitions of Outputs =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Roll Loop Opened, Others Closed
! Roll Loop Opened for Roll Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                                       Roll Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  1, Gain= -1.0                                                  DP_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw Closed
..............................................................................
Definitions of Inputs  =   1
Roll Control Demand DP_tvc 

Definitions of Outputs =   1
Roll Control Demand DP_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Pitch Loop Opened, Others Closed
! Pitch Loop Opened for Pitch Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  2, Gain= 1.0                                                       Pitch Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  2, Gain= -1.0                                                  DQ_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw  Closed
..............................................................................
Definitions of Inputs  =   1
Pitch Control Demand DQ_tvc 

Definitions of Outputs =   1
Pitch Control Demand DQ_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Yaw Loop Opened, Others Closed
! Roll Loop Opened for Yaw Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  3, Gain= 1.0                                                       Yaw Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  3, Gain= -1.0                                                  DR_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll  Closed
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
..............................................................................
Definitions of Inputs  =   1
Yaw Control Demand DR_tvc 

Definitions of Outputs =   1
Yaw Control Demand DR_tvc 
--------------------------------------------------------------------------------------------------------------------------------
                            CONVERT TO MATLAB DATA
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=60.0 sec 
Matrix TVC
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=60.0 sec 
System
flex_vehicle.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Flight Control System
System
fcs.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model at T=60 sec, Vehicle/ Actuators
System
plant.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Closed-Loop System
System
closed_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Open-Loop System
System
open_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Roll Loop Opened, Others Closed
System
roll_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Loop Opened, Others Closed
System
pitch_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Yaw Loop Opened, Others Closed
System
yaw_open.m
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 70% Full
First Stage Flex Modes at 70% Full Tanks
! Flex Modes, First Stage 70% Full Tanks from Files: Stg1_70%.Mod, Stg1_70%.Nod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    23.165       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.15550D-01   0.13791D+00  -0.40095D-02  -0.27974D-05  -0.18251D-03  -0.64210D-02
S1 Engine No:2 +Y-Z               1152     0.68120D-02   0.13790D+00  -0.40081D-02   0.38291D-06  -0.18164D-03  -0.64368D-02
S1 Engine No:3 -Y-Z               1153    -0.59210D-02   0.13790D+00  -0.40106D-02   0.17814D-06  -0.19171D-03  -0.64370D-02
S1 Engine No:4 -Y-Z               1154    -0.15182D-01   0.13791D+00  -0.40091D-02  -0.25952D-05  -0.19200D-03  -0.64212D-02
S1 Engine No:5 -Y+Z               1155    -0.15552D-01   0.13791D+00  -0.40091D-02   0.28786D-05  -0.18262D-03  -0.64211D-02
S1 Engine No:6 -Y+Z               1156    -0.68146D-02   0.13790D+00  -0.40081D-02  -0.74135D-06  -0.18146D-03  -0.64369D-02
S1 Engine No:7 +Y+Z               1157     0.59186D-02   0.13790D+00  -0.40111D-02  -0.37415D-06  -0.19187D-03  -0.64372D-02
S1 Engine No:8 +Y+Z               1158     0.15179D-01   0.13791D+00  -0.40096D-02   0.29459D-05  -0.19174D-03  -0.64212D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02  -0.17551D-07   0.13211D-03   0.45448D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02  -0.17551D-07   0.13211D-03   0.45448D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02  -0.17551D-07   0.13211D-03   0.45448D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10007D-05   0.37440D-01  -0.10880D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.11284D-05  -0.71681D-01   0.20846D-02  -0.16706D-07   0.10688D-05   0.36280D-04
Fuel Slosh Mass Locat.             600    -0.12406D-05   0.27523D-01  -0.79968D-03  -0.15263D-07  -0.16930D-03  -0.58223D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.52334D-04  -0.90953D-02   0.26381D-03  -0.15445D-07   0.12810D-03   0.44320D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    23.168       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.59220D-02   0.40122D-02   0.13796D+00   0.12325D-06   0.64394D-02  -0.19189D-03
S1 Engine No:2 +Y-Z               1152    -0.15187D-01   0.40109D-02   0.13796D+00  -0.25798D-05   0.64238D-02  -0.19204D-03
S1 Engine No:3 -Y-Z               1153    -0.15557D-01   0.40108D-02   0.13796D+00   0.25105D-05   0.64235D-02  -0.18241D-03
S1 Engine No:4 -Y-Z               1154    -0.68158D-02   0.40099D-02   0.13796D+00  -0.52700D-06   0.64392D-02  -0.18154D-03
S1 Engine No:5 -Y+Z               1155     0.59221D-02   0.40127D-02   0.13796D+00  -0.45282D-06   0.64396D-02  -0.19195D-03
S1 Engine No:6 -Y+Z               1156     0.15187D-01   0.40115D-02   0.13796D+00   0.27085D-05   0.64237D-02  -0.19186D-03
S1 Engine No:7 +Y+Z               1157     0.15557D-01   0.40114D-02   0.13796D+00  -0.28032D-05   0.64235D-02  -0.18247D-03
S1 Engine No:8 +Y+Z               1158     0.68157D-02   0.40100D-02   0.13796D+00   0.32642D-06   0.64393D-02  -0.18155D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01  -0.10910D-06  -0.45445D-02   0.13216D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01  -0.10910D-06  -0.45445D-02   0.13216D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01  -0.10910D-06  -0.45445D-02   0.13216D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.25260D-07   0.10886D-02   0.37421D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.29130D-07  -0.20844D-02  -0.71711D-01  -0.10240D-06  -0.36282D-04   0.10409D-05
Fuel Slosh Mass Locat.             600    -0.32654D-07   0.80100D-03   0.27531D-01  -0.91894D-07   0.58246D-02  -0.16933D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.15264D-05  -0.26466D-03  -0.90811D-02  -0.18142D-06  -0.44068D-02   0.12888D-03

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.781       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.23743D-02  -0.13026D-01  -0.67753D-06   0.10127D-05  -0.12755D-05   0.91836D-03
S1 Engine No:2 +Y-Z               1152    -0.10837D-02  -0.13025D-01  -0.12095D-05  -0.11248D-06  -0.13066D-05   0.92345D-03
S1 Engine No:3 -Y-Z               1153     0.74377D-03  -0.13025D-01  -0.32788D-06  -0.93373D-07   0.15685D-05   0.92330D-03
S1 Engine No:4 -Y-Z               1154     0.20343D-02  -0.13026D-01  -0.85342D-06   0.94314D-06   0.14558D-05   0.91802D-03
S1 Engine No:5 -Y+Z               1155     0.20344D-02  -0.13026D-01  -0.84713D-06  -0.10526D-05  -0.13692D-05   0.91811D-03
S1 Engine No:6 -Y+Z               1156     0.74375D-03  -0.13025D-01  -0.12356D-05   0.24716D-06  -0.16898D-05   0.92335D-03
S1 Engine No:7 +Y+Z               1157    -0.10838D-02  -0.13025D-01  -0.17643D-06   0.16235D-06   0.13207D-05   0.92345D-03
S1 Engine No:8 +Y+Z               1158    -0.23744D-02  -0.13026D-01  -0.68202D-06  -0.10849D-05   0.12176D-05   0.91837D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07   0.76729D-08   0.27582D-07   0.14190D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07   0.76729D-08   0.27582D-07   0.14190D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07   0.76729D-08   0.27582D-07   0.14190D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.10809D-03   0.42076D-02  -0.46490D-07

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.14271D-03   0.31476D-02   0.29039D-06   0.60719D-08  -0.12767D-07  -0.63972D-03
Fuel Slosh Mass Locat.             600    -0.16534D-03   0.26775D-02  -0.49008D-06   0.36887D-08  -0.24337D-07   0.71428D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.41687D-02  -0.40163D-01   0.26717D-06   0.71362D-07   0.70616D-07   0.25938D-01

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    52.423       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.12631D-02   0.17219D-05   0.16773D-01   0.78888D-08   0.12762D-02  -0.23600D-05
S1 Engine No:2 +Y-Z               1152    -0.30468D-02   0.75187D-06   0.16775D-01  -0.16874D-05   0.12679D-02  -0.22279D-05
S1 Engine No:3 -Y-Z               1153    -0.30468D-02   0.82134D-06   0.16775D-01   0.14153D-05   0.12679D-02   0.21917D-05
S1 Engine No:4 -Y-Z               1154    -0.12631D-02   0.33683D-06   0.16774D-01  -0.39086D-06   0.12762D-02   0.23857D-05
S1 Engine No:5 -Y+Z               1155     0.12632D-02   0.22278D-05   0.16774D-01  -0.44684D-06   0.12763D-02  -0.23928D-05
S1 Engine No:6 -Y+Z               1156     0.30468D-02   0.16715D-05   0.16775D-01   0.15662D-05   0.12678D-02  -0.21004D-05
S1 Engine No:7 +Y+Z               1157     0.30467D-02   0.17010D-05   0.16775D-01  -0.18240D-05   0.12678D-02   0.21523D-05
S1 Engine No:8 +Y+Z               1158     0.12631D-02   0.64424D-06   0.16773D-01   0.31814D-07   0.12762D-02   0.23784D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02  -0.80027D-07   0.25384D-02   0.54384D-07
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02  -0.80027D-07   0.25384D-02   0.54384D-07
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02  -0.80027D-07   0.25384D-02   0.54384D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02
Stage-2 Tank Top, IMU Locat.     40015     0.82545D-09   0.18081D-07  -0.28885D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.89429D-09  -0.57449D-06   0.74641D-05  -0.13192D-06  -0.11248D-02  -0.27256D-07
Fuel Slosh Mass Locat.             600     0.85507D-09   0.97189D-06  -0.48286D-02  -0.16158D-06   0.93014D-03  -0.40187D-07

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.14439D-07  -0.35999D-06   0.60110D-01   0.46358D-05   0.34082D-01  -0.43470D-07

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.292       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.88383D-02  -0.42388D-01   0.28633D-04   0.70744D-05  -0.43632D-05   0.36929D-02
S1 Engine No:2 +Y-Z               1152    -0.36378D-02  -0.42381D-01   0.24890D-04  -0.84619D-06  -0.51253D-05   0.37260D-02
S1 Engine No:3 -Y-Z               1153     0.37399D-02  -0.42381D-01   0.31008D-04  -0.66689D-06   0.10914D-04   0.37260D-02
S1 Engine No:4 -Y-Z               1154     0.89492D-02  -0.42388D-01   0.27341D-04   0.65297D-05   0.11012D-04   0.36930D-02
S1 Engine No:5 -Y+Z               1155     0.89565D-02  -0.42386D-01   0.27617D-04  -0.74300D-05  -0.39385D-05   0.36936D-02
S1 Engine No:6 -Y+Z               1156     0.37551D-02  -0.42380D-01   0.24863D-04   0.17440D-05  -0.54304D-05   0.37264D-02
S1 Engine No:7 +Y+Z               1157    -0.36232D-02  -0.42380D-01   0.32151D-04   0.11253D-05   0.11607D-04   0.37260D-02
S1 Engine No:8 +Y+Z               1158    -0.88326D-02  -0.42387D-01   0.28477D-04  -0.76895D-05   0.10358D-04   0.36929D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04   0.95668D-07   0.84137D-05   0.10372D-01
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04   0.95668D-07   0.84137D-05   0.10372D-01
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04   0.95668D-07   0.84137D-05   0.10372D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04
Stage-2 Tank Top, IMU Locat.     40015     0.94768D-05  -0.24393D-01   0.19926D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.35923D-04  -0.23364D-01   0.22111D-04   0.55711D-07  -0.35735D-05  -0.43481D-02
Fuel Slosh Mass Locat.             600     0.54019D-04   0.19653D-01  -0.21773D-04   0.40217D-08   0.16496D-05   0.23341D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.11846D-02  -0.91084D-01   0.68191D-04   0.12181D-06  -0.43339D-05   0.37074D-03

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.734       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.35643D-02   0.43613D-04   0.40963D-01   0.57449D-06   0.36072D-02  -0.11121D-04
S1 Engine No:2 +Y-Z               1152    -0.86084D-02   0.40413D-04   0.40969D-01  -0.62916D-05   0.35755D-02  -0.10729D-04
S1 Engine No:3 -Y-Z               1153    -0.86145D-02   0.40825D-04   0.40969D-01   0.62947D-05   0.35756D-02   0.46606D-05
S1 Engine No:4 -Y-Z               1154    -0.35786D-02   0.38082D-04   0.40963D-01  -0.10580D-05   0.36073D-02   0.53785D-05
S1 Engine No:5 -Y+Z               1155     0.35645D-02   0.44618D-04   0.40963D-01  -0.12787D-05   0.36076D-02  -0.11259D-04
S1 Engine No:6 -Y+Z               1156     0.86084D-02   0.41557D-04   0.40970D-01   0.69301D-05   0.35755D-02  -0.10189D-04
S1 Engine No:7 +Y+Z               1157     0.86140D-02   0.41801D-04   0.40970D-01  -0.68719D-05   0.35754D-02   0.44951D-05
S1 Engine No:8 +Y+Z               1158     0.35784D-02   0.38244D-04   0.40963D-01   0.68670D-06   0.36073D-02   0.53466D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01  -0.28380D-07   0.10126D-01  -0.86638D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01  -0.28380D-07   0.10126D-01  -0.86638D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01  -0.28380D-07   0.10126D-01  -0.86638D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.15787D-07   0.21301D-04   0.25054D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.35129D-07   0.16665D-04   0.23135D-01  -0.90401D-07  -0.42318D-02   0.35742D-05
Fuel Slosh Mass Locat.             600    -0.46460D-07  -0.10540D-04  -0.19091D-01  -0.12196D-06   0.22529D-02  -0.21658D-05

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.96870D-06   0.76376D-04   0.82656D-01   0.43830D-05  -0.49943D-02  -0.32402D-06

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    105.16       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.87183D-05   0.18241D-01   0.43981D-01   0.18433D-01  -0.21389D-05  -0.24180D-05
S1 Engine No:2 +Y-Z               1152     0.77367D-05   0.44013D-01   0.18209D-01   0.18433D-01  -0.25492D-05  -0.29365D-05
S1 Engine No:3 -Y-Z               1153     0.17214D-05   0.44013D-01  -0.18239D-01   0.18433D-01  -0.15818D-05  -0.29368D-05
S1 Engine No:4 -Y-Z               1154    -0.51446D-05   0.18241D-01  -0.44012D-01   0.18433D-01  -0.20846D-05  -0.24756D-05
S1 Engine No:5 -Y+Z               1155    -0.94842D-05  -0.18207D-01  -0.44012D-01   0.18433D-01  -0.20910D-05  -0.34237D-05
S1 Engine No:6 -Y+Z               1156    -0.81530D-05  -0.43979D-01  -0.18239D-01   0.18433D-01  -0.16414D-05  -0.29576D-05
S1 Engine No:7 +Y+Z               1157    -0.24976D-05  -0.43979D-01   0.18209D-01   0.18433D-01  -0.25831D-05  -0.29686D-05
S1 Engine No:8 +Y+Z               1158     0.47149D-05  -0.18207D-01   0.43981D-01   0.18433D-01  -0.21140D-05  -0.33794D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04  -0.19519D-01  -0.19493D-05  -0.15481D-05
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04  -0.19519D-01  -0.19493D-05  -0.15481D-05
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04  -0.19519D-01  -0.19493D-05  -0.15481D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04
Stage-2 Tank Top, IMU Locat.     40015     0.32494D-06  -0.69558D-05   0.10697D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.52208D-07   0.19768D-04  -0.16391D-04   0.25034D-02   0.12001D-05   0.12089D-05
Fuel Slosh Mass Locat.             600    -0.18076D-06  -0.23278D-04   0.15433D-04   0.15432D-01  -0.69907D-06  -0.69240D-06

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.53740D-06   0.12003D-04  -0.21088D-04  -0.31561D+00  -0.57034D-05  -0.14023D-05

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    109.14       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.25200D-01   0.80058D-01  -0.51624D-02  -0.30637D-04  -0.66875D-03  -0.10341D-01
S1 Engine No:2 +Y-Z               1152     0.11560D-01   0.80028D-01  -0.51519D-02   0.11118D-04  -0.65851D-03  -0.10465D-01
S1 Engine No:3 -Y-Z               1153    -0.91652D-02   0.80028D-01  -0.51901D-02   0.60340D-05  -0.68563D-03  -0.10468D-01
S1 Engine No:4 -Y-Z               1154    -0.24709D-01   0.80058D-01  -0.51759D-02  -0.26922D-04  -0.69704D-03  -0.10347D-01
S1 Engine No:5 -Y+Z               1155    -0.26067D-01   0.80038D-01  -0.51795D-02   0.42496D-04  -0.67272D-03  -0.10348D-01
S1 Engine No:6 -Y+Z               1156    -0.12422D-01   0.79999D-01  -0.51613D-02  -0.69611D-05  -0.65993D-03  -0.10469D-01
S1 Engine No:7 +Y+Z               1157     0.83073D-02   0.79999D-01  -0.51876D-02   0.10664D-05  -0.69256D-03  -0.10467D-01
S1 Engine No:8 +Y+Z               1158     0.23851D-01   0.80045D-01  -0.51596D-02   0.43313D-04  -0.69467D-03  -0.10343D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02  -0.71111D-05  -0.58105D-03  -0.91090D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02  -0.71111D-05  -0.58105D-03  -0.91090D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02  -0.71111D-05  -0.58105D-03  -0.91090D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43217D-03  -0.31166D-01   0.19847D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.52086D-05   0.81940D-01  -0.53014D-02  -0.15496D-05   0.37590D-03   0.58519D-02
Fuel Slosh Mass Locat.             600    -0.32492D-03  -0.75176D-01   0.49178D-02   0.31368D-05  -0.23357D-03  -0.36306D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.15582D-02   0.70509D-01  -0.43331D-02   0.19550D-03  -0.36396D-03  -0.77382D-02

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    109.67       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.87107D-02   0.53151D-02   0.81898D-01   0.68819D-05   0.10371D-01  -0.67382D-03
S1 Engine No:2 +Y-Z               1152    -0.24099D-01   0.53041D-02   0.81925D-01  -0.26263D-04   0.10244D-01  -0.68219D-03
S1 Engine No:3 -Y-Z               1153    -0.25415D-01   0.53083D-02   0.81910D-01   0.39185D-04   0.10242D-01  -0.64621D-03
S1 Engine No:4 -Y-Z               1154    -0.11877D-01   0.52875D-02   0.81870D-01  -0.18780D-05   0.10369D-01  -0.63594D-03
S1 Engine No:5 -Y+Z               1155     0.86627D-02   0.53082D-02   0.81870D-01   0.14603D-05   0.10372D-01  -0.67501D-03
S1 Engine No:6 -Y+Z               1156     0.24050D-01   0.52810D-02   0.81915D-01   0.42085D-04   0.10243D-01  -0.67920D-03
S1 Engine No:7 +Y+Z               1157     0.25363D-01   0.52843D-02   0.81926D-01  -0.30389D-04   0.10240D-01  -0.64709D-03
S1 Engine No:8 +Y+Z               1158     0.11827D-01   0.52760D-02   0.81898D-01   0.12358D-04   0.10369D-01  -0.63598D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01  -0.61858D-05   0.95567D-02  -0.62633D-03
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01  -0.61858D-05   0.95567D-02  -0.62633D-03
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01  -0.61858D-05   0.95567D-02  -0.62633D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01
Stage-2 Tank Top, IMU Locat.     40015     0.24007D-04  -0.20703D-02  -0.31536D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.13277D-05   0.53628D-02   0.83039D-01   0.92104D-06  -0.60229D-02   0.39192D-03
Fuel Slosh Mass Locat.             600    -0.19221D-04  -0.46963D-02  -0.73635D-01   0.47174D-05   0.37556D-02  -0.24395D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.10084D-03   0.48422D-02   0.71211D-01  -0.68554D-04   0.59428D-02  -0.52751D-03

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    112.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.93662D-05   0.23058D-01   0.55768D-01   0.23366D-01  -0.92538D-06   0.46850D-05
S1 Engine No:2 +Y-Z               1152    -0.22618D-05   0.55728D-01   0.23098D-01   0.23366D-01  -0.15552D-05   0.40442D-05
S1 Engine No:3 -Y-Z               1153     0.54721D-05   0.55728D-01  -0.23104D-01   0.23366D-01  -0.11462D-06   0.40553D-05
S1 Engine No:4 -Y-Z               1154     0.10161D-04   0.23058D-01  -0.55774D-01   0.23366D-01  -0.81298D-06   0.46126D-05
S1 Engine No:5 -Y+Z               1155     0.82152D-05  -0.23144D-01  -0.55774D-01   0.23366D-01  -0.85463D-06   0.32232D-05
S1 Engine No:6 -Y+Z               1156     0.16167D-05  -0.55814D-01  -0.23104D-01   0.23366D-01  -0.23843D-06   0.40162D-05
S1 Engine No:7 +Y+Z               1157    -0.66464D-05  -0.55814D-01   0.23098D-01   0.23366D-01  -0.15698D-05   0.40103D-05
S1 Engine No:8 +Y+Z               1158    -0.10829D-04  -0.23144D-01   0.55768D-01   0.23366D-01  -0.85909D-06   0.32999D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05  -0.29766D-01   0.61900D-06   0.65926D-05
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05  -0.29766D-01   0.61900D-06   0.65926D-05
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05  -0.29766D-01   0.61900D-06   0.65926D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05
Stage-2 Tank Top, IMU Locat.     40015     0.52915D-06   0.18155D-04  -0.28229D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.89976D-07  -0.42315D-04  -0.23868D-05   0.10532D-02  -0.77256D-07  -0.35610D-05
Fuel Slosh Mass Locat.             600    -0.27510D-06   0.25494D-04   0.70629D-05   0.19020D-01  -0.20095D-07   0.21922D-05

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.23209D-06  -0.50491D-04   0.96230D-05   0.22494D+00   0.37220D-05   0.53038D-05

MODE# 11/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    125.79       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.23477D-01  -0.37360D-01   0.29625D-02   0.31690D-04   0.70494D-03   0.84546D-02
S1 Engine No:2 +Y-Z               1152    -0.12650D-01  -0.37320D-01   0.29371D-02   0.71638D-05   0.71615D-03   0.84600D-02
S1 Engine No:3 -Y-Z               1153     0.40454D-02  -0.37319D-01   0.29300D-02   0.10374D-04   0.66167D-03   0.84392D-02
S1 Engine No:4 -Y-Z               1154     0.16744D-01  -0.37359D-01   0.29010D-02   0.29248D-04   0.65681D-03   0.84122D-02
S1 Engine No:5 -Y+Z               1155     0.18076D-01  -0.37372D-01   0.29057D-02  -0.12194D-04   0.69000D-03   0.84190D-02
S1 Engine No:6 -Y+Z               1156     0.72438D-02  -0.37366D-01   0.29142D-02   0.19027D-04   0.67646D-03   0.84452D-02
S1 Engine No:7 +Y+Z               1157    -0.94540D-02  -0.37366D-01   0.29554D-02   0.12730D-04   0.62611D-03   0.84562D-02
S1 Engine No:8 +Y+Z               1158    -0.22152D-01  -0.37378D-01   0.29567D-02  -0.12468D-04   0.63700D-03   0.84504D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03  -0.18386D-04  -0.74520D-03  -0.92041D-02
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03  -0.18386D-04  -0.74520D-03  -0.92041D-02
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03  -0.18386D-04  -0.74520D-03  -0.92041D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03
Stage-2 Tank Top, IMU Locat.     40015     0.29644D-02  -0.97351D-02   0.78570D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.47265D-03  -0.12763D-01   0.96494D-03   0.64663D-05   0.13202D-03   0.15952D-02
Fuel Slosh Mass Locat.             600    -0.23257D-02   0.61932D-01  -0.49279D-02   0.12586D-04   0.40416D-04   0.54295D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303     0.40998D-02   0.64433D-01  -0.50637D-02   0.33564D-04  -0.38874D-03  -0.62719D-02

MODE# 12/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    130.33       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.10100D-01   0.63304D-02   0.77416D-01   0.34349D-05   0.12784D-01  -0.10215D-02
S1 Engine No:2 +Y-Z               1152    -0.29351D-01   0.63073D-02   0.77462D-01  -0.39294D-04   0.12667D-01  -0.10334D-02
S1 Engine No:3 -Y-Z               1153    -0.31407D-01   0.63158D-02   0.77450D-01   0.47026D-04   0.12668D-01  -0.10441D-02
S1 Engine No:4 -Y-Z               1154    -0.15045D-01   0.62959D-02   0.77402D-01  -0.84978D-05   0.12786D-01  -0.10336D-02
S1 Engine No:5 -Y+Z               1155     0.10255D-01   0.63315D-02   0.77402D-01  -0.25352D-05   0.12787D-01  -0.10217D-02
S1 Engine No:6 -Y+Z               1156     0.29504D-01   0.63006D-02   0.77457D-01   0.51032D-04   0.12667D-01  -0.10284D-02
S1 Engine No:7 +Y+Z               1157     0.31555D-01   0.63077D-02   0.77462D-01  -0.45578D-04   0.12667D-01  -0.10460D-02
S1 Engine No:8 +Y+Z               1158     0.15198D-01   0.62902D-02   0.77416D-01   0.12510D-04   0.12787D-01  -0.10352D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02  -0.51385D-05  -0.10456D-01   0.83935D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02  -0.51385D-05  -0.10456D-01   0.83935D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02  -0.51385D-05  -0.10456D-01   0.83935D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.84059D-04   0.53496D-03   0.66339D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.24372D-04   0.30574D-02   0.37230D-01   0.22226D-05   0.53663D-03  -0.40063D-04
Fuel Slosh Mass Locat.             600     0.71908D-04  -0.72213D-02  -0.88983D-01   0.32897D-05   0.22026D-02  -0.18067D-03

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.17362D-03  -0.55829D-02  -0.67625D-01   0.26948D-04  -0.51233D-02   0.53093D-03

MODE# 13/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    143.17       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.27631D-01  -0.10983D+00   0.89210D-02   0.91120D-04   0.86302D-03   0.11065D-01
S1 Engine No:2 +Y-Z               1152    -0.13014D-01  -0.10974D+00   0.88764D-02  -0.16187D-04   0.82622D-03   0.11429D-01
S1 Engine No:3 -Y-Z               1153     0.97033D-02  -0.10974D+00   0.89490D-02  -0.93682D-06   0.96103D-03   0.11442D-01
S1 Engine No:4 -Y-Z               1154     0.26906D-01  -0.10983D+00   0.88931D-02   0.81682D-04   0.99641D-03   0.11084D-01
S1 Engine No:5 -Y+Z               1155     0.28766D-01  -0.10981D+00   0.88970D-02  -0.92485D-04   0.87235D-03   0.11080D-01
S1 Engine No:6 -Y+Z               1156     0.14137D-01  -0.10974D+00   0.88720D-02   0.33662D-04   0.82909D-03   0.11438D-01
S1 Engine No:7 +Y+Z               1157    -0.85892D-02  -0.10974D+00   0.89703D-02   0.11010D-04   0.97657D-03   0.11440D-01
S1 Engine No:8 +Y+Z               1158    -0.25792D-01  -0.10983D+00   0.89189D-02  -0.93733D-04   0.99043D-03   0.11077D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03   0.11296D-04  -0.63011D-03  -0.77250D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03   0.11296D-04  -0.63011D-03  -0.77250D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03   0.11296D-04  -0.63011D-03  -0.77250D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.82637D-03   0.31180D-02  -0.25544D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.32071D-03  -0.73955D-01   0.59980D-02  -0.82990D-05  -0.20558D-03  -0.25409D-02
Fuel Slosh Mass Locat.             600     0.63387D-03   0.76547D-01  -0.62183D-02  -0.45654D-05   0.39862D-03   0.49130D-02

                              Node ID#     Modal Data at the Disturbance Point 
S2 Engine Gimbal                  3303    -0.28389D-03   0.40968D-01  -0.32643D-02  -0.71724D-05  -0.22320D-03  -0.34642D-02

MODE# 14/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    150.00       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.50203D-02   0.64385D-02   0.78979D-01   0.82655D-05   0.62018D-02  -0.55928D-03
S1 Engine No:2 +Y-Z               1152    -0.14345D-01   0.64070D-02   0.79038D-01  -0.59785D-04   0.58723D-02  -0.58258D-03
S1 Engine No:3 -Y-Z               1153    -0.15349D-01   0.64080D-02   0.79019D-01   0.73248D-04   0.58598D-02  -0.42329D-03
S1 Engine No:4 -Y-Z               1154    -0.74201D-02   0.63759D-02   0.78954D-01  -0.12913D-04   0.61902D-02  -0.38924D-03
