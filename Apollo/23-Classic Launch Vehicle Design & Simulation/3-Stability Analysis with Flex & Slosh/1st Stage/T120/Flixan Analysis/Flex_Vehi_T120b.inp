S1 Engine No:2 +Y-Z               1152    -0.50386D-01   0.10335D-01   0.13722D+00  -0.18038D-03   0.21359D-01  -0.16420D-02
S1 Engine No:3 -Y-Z               1153    -0.53671D-01   0.10362D-01   0.13718D+00   0.20636D-03   0.21366D-01  -0.16698D-02
S1 Engine No:4 -Y-Z               1154    -0.25628D-01   0.10277D-01   0.13698D+00  -0.48680D-04   0.21913D-01  -0.16282D-02
S1 Engine No:5 -Y+Z               1155     0.17796D-01   0.10462D-01   0.13698D+00  -0.23178D-04   0.21916D-01  -0.15914D-02
S1 Engine No:6 -Y+Z               1156     0.50395D-01   0.10330D-01   0.13722D+00   0.22397D-03   0.21355D-01  -0.16207D-02
S1 Engine No:7 +Y+Z               1157     0.53658D-01   0.10351D-01   0.13723D+00  -0.20909D-03   0.21355D-01  -0.16757D-02
S1 Engine No:8 +Y+Z               1158     0.25633D-01   0.10261D-01   0.13702D+00   0.54298D-04   0.21914D-01  -0.16308D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.27421D-06  -0.20692D-02  -0.27072D-01   0.39275D-05  -0.46027D-02   0.35140D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.27421D-06  -0.20692D-02  -0.27072D-01   0.39275D-05  -0.46027D-02   0.35140D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.27421D-06  -0.20692D-02  -0.27072D-01   0.39275D-05  -0.46027D-02   0.35140D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.27421D-06  -0.20692D-02  -0.27072D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.27421D-06  -0.20692D-02  -0.27072D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.42249D-04   0.84699D-02   0.11207D+00  -0.10063D-04  -0.12205D-01   0.92376D-03
Fuel Slosh Mass Locat.             600    -0.11579D-04  -0.83827D-02  -0.11130D+00   0.79404D-06   0.13140D-01  -0.99168D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.54068D-03   0.29266D-02   0.40856D-01   0.29988D-02  -0.41516D-01   0.32564D-02

MODE# 15/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    233.53       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.33199D-01  -0.78568D-01   0.14137D-02   0.25657D-03   0.31771D-03   0.13867D-01
S1 Engine No:2 +Y-Z               1152    -0.13917D-01  -0.78272D-01   0.12126D-02   0.29546D-04   0.31271D-03   0.14278D-01
S1 Engine No:3 -Y-Z               1153     0.14345D-01  -0.78273D-01   0.12511D-02   0.41050D-04   0.10707D-03   0.14285D-01
S1 Engine No:4 -Y-Z               1154     0.34282D-01  -0.78562D-01   0.10499D-02   0.23340D-03   0.16042D-03   0.13894D-01
S1 Engine No:5 -Y+Z               1155     0.34795D-01  -0.78622D-01   0.10692D-02  -0.14554D-03   0.34914D-03   0.13921D-01
S1 Engine No:6 -Y+Z               1156     0.15480D-01  -0.78530D-01   0.10840D-02   0.13645D-03   0.33098D-03   0.14311D-01
S1 Engine No:7 +Y+Z               1157    -0.12813D-01  -0.78532D-01   0.14290D-02   0.10474D-03   0.15715D-03   0.14276D-01
S1 Engine No:8 +Y+Z               1158    -0.32746D-01  -0.78661D-01   0.14001D-02  -0.15419D-03   0.14551D-03   0.13862D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.44066D-02  -0.53672D-01   0.92042D-03   0.11069D-04   0.48586D-04   0.28393D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.44066D-02  -0.53672D-01   0.92042D-03   0.11069D-04   0.48586D-04   0.28393D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.44066D-02  -0.53672D-01   0.92042D-03   0.11069D-04   0.48586D-04   0.28393D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.44066D-02  -0.53672D-01   0.92042D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.44066D-02  -0.53672D-01   0.92042D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10332D-03   0.18213D-01  -0.39871D-03  -0.39799D-04   0.13043D-03   0.70561D-02
Fuel Slosh Mass Locat.             600     0.61673D-03   0.71730D-01  -0.12142D-02   0.36856D-04   0.10512D-03   0.66370D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.19577D-02  -0.47152D-01   0.15000D-02   0.32166D-02   0.47111D-03  -0.43904D-02

MODE# 16/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    234.35       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.13608D-01  -0.15139D-02  -0.79763D-01  -0.84017D-04  -0.14310D-01   0.14527D-03
S1 Engine No:2 +Y-Z               1152     0.33621D-01  -0.14997D-02  -0.79866D-01   0.11022D-03  -0.13916D-01   0.17138D-03
S1 Engine No:3 -Y-Z               1153     0.34100D-01  -0.15233D-02  -0.79732D-01  -0.23729D-03  -0.13920D-01   0.30941D-03
S1 Engine No:4 -Y-Z               1154     0.14735D-01  -0.13598D-02  -0.79473D-01  -0.13570D-04  -0.14317D-01   0.30925D-03
S1 Engine No:5 -Y+Z               1155    -0.13612D-01  -0.14334D-02  -0.79472D-01  -0.14942D-04  -0.14321D-01   0.14880D-03
S1 Engine No:6 -Y+Z               1156    -0.33613D-01  -0.12487D-02  -0.79755D-01  -0.25927D-03  -0.13912D-01   0.14988D-03
S1 Engine No:7 +Y+Z               1157    -0.34069D-01  -0.12662D-02  -0.79884D-01   0.13344D-03  -0.13910D-01   0.31386D-03
S1 Engine No:8 +Y+Z               1158    -0.14722D-01  -0.12424D-02  -0.79763D-01  -0.91769D-04  -0.14315D-01   0.31146D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.82643D-04  -0.86938D-03  -0.54057D-01  -0.10144D-04  -0.27701D-02   0.44663D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.82643D-04  -0.86938D-03  -0.54057D-01  -0.10144D-04  -0.27701D-02   0.44663D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.82643D-04  -0.86938D-03  -0.54057D-01  -0.10144D-04  -0.27701D-02   0.44663D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.82643D-04  -0.86938D-03  -0.54057D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.82643D-04  -0.86938D-03  -0.54057D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.76462D-05   0.23027D-03   0.19581D-01   0.35825D-04  -0.72974D-02   0.10810D-03
Fuel Slosh Mass Locat.             600     0.80427D-05   0.11628D-02   0.71488D-01  -0.33862D-04  -0.66966D-02   0.11609D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.12144D-03   0.11844D-03  -0.36189D-01  -0.26682D-02   0.12792D-01  -0.76006D-03

MODE# 17/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    244.36       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.48585D-04  -0.55633D-01  -0.13364D+00  -0.56051D-01   0.14831D-04   0.53123D-05
S1 Engine No:2 +Y-Z               1152    -0.49073D-04  -0.13402D+00  -0.55256D-01  -0.56053D-01   0.20471D-04   0.16919D-04
S1 Engine No:3 -Y-Z               1153    -0.10344D-04  -0.13402D+00   0.55605D-01  -0.56051D-01   0.42394D-05   0.17702D-04
S1 Engine No:4 -Y-Z               1154     0.30102D-04  -0.55633D-01   0.13399D+00  -0.56051D-01   0.15037D-04   0.73067D-05
S1 Engine No:5 -Y+Z               1155     0.63554D-04   0.55228D-01   0.13399D+00  -0.56052D-01   0.14340D-04   0.23375D-04
S1 Engine No:6 -Y+Z               1156     0.57008D-04   0.13362D+00   0.55604D-01  -0.56052D-01   0.45979D-05   0.17110D-04
S1 Engine No:7 +Y+Z               1157     0.25409D-04   0.13362D+00  -0.55255D-01  -0.56052D-01   0.22217D-04   0.17916D-04
S1 Engine No:8 +Y+Z               1158    -0.21944D-04   0.55227D-01  -0.13364D+00  -0.56053D-01   0.15317D-04   0.23076D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.22772D-04  -0.73961D-04   0.62340D-04  -0.76232D-02   0.21617D-05   0.25624D-05
Stage-2 Tank Top, IMU Locat.     40015     0.22772D-04  -0.73961D-04   0.62340D-04  -0.76232D-02   0.21617D-05   0.25624D-05
Stage-2 Tank Top, IMU Locat.     40015     0.22772D-04  -0.73961D-04   0.62340D-04  -0.76232D-02   0.21617D-05   0.25624D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.22772D-04  -0.73961D-04   0.62340D-04
Stage-2 Tank Top, IMU Locat.     40015     0.22772D-04  -0.73961D-04   0.62340D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.70337D-05  -0.34289D-04   0.29663D-04   0.29748D-01   0.34316D-05   0.41662D-05
Fuel Slosh Mass Locat.             600     0.16090D-05   0.61276D-04  -0.50913D-04  -0.35144D-01   0.13565D-04   0.15856D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.62609D-04   0.89059D-03  -0.68921D-03  -0.22063D+00  -0.40775D-03  -0.57448D-03

MODE# 18/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    281.91       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.75440D-03   0.13664D-01   0.29526D-01   0.12713D-01  -0.28844D-03  -0.35902D-03
S1 Engine No:2 +Y-Z               1152     0.65048D-03   0.31448D-01   0.11738D-01   0.12722D-01  -0.28867D-03  -0.36413D-03
S1 Engine No:3 -Y-Z               1153    -0.60413D-04   0.31448D-01  -0.13422D-01   0.12715D-01  -0.26132D-03  -0.36048D-03
S1 Engine No:4 -Y-Z               1154    -0.93774D-03   0.13667D-01  -0.31204D-01   0.12715D-01  -0.26917D-03  -0.36841D-03
S1 Engine No:5 -Y+Z               1155    -0.14974D-02  -0.11495D-01  -0.31205D-01   0.12725D-01  -0.30064D-03  -0.39094D-03
S1 Engine No:6 -Y+Z               1156    -0.13898D-02  -0.29286D-01  -0.13420D-01   0.12713D-01  -0.30883D-03  -0.37682D-03
S1 Engine No:7 +Y+Z               1157    -0.67950D-03  -0.29287D-01   0.11731D-01   0.12720D-01  -0.29281D-03  -0.34921D-03
S1 Engine No:8 +Y+Z               1158     0.19945D-03  -0.11492D-01   0.29526D-01   0.12724D-01  -0.27959D-03  -0.34760D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.49030D-04   0.12689D-03  -0.98711D-04   0.87402D-03  -0.15904D-06  -0.33767D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.49030D-04   0.12689D-03  -0.98711D-04   0.87402D-03  -0.15904D-06  -0.33767D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.49030D-04   0.12689D-03  -0.98711D-04   0.87402D-03  -0.15904D-06  -0.33767D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.49030D-04   0.12689D-03  -0.98711D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.49030D-04   0.12689D-03  -0.98711D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.18602D-03   0.28576D-03  -0.21107D-03  -0.43031D-02   0.29802D-04   0.40160D-04
Fuel Slosh Mass Locat.             600    -0.22498D-03  -0.17517D-02   0.13830D-02   0.90210D-02  -0.69874D-04  -0.89729D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.21767D-03   0.73214D-02  -0.53168D-02  -0.11554D+01  -0.22488D-02  -0.36202D-02

MODE# 19/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    293.68       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.56995D-01   0.10890D+00  -0.30060D-02  -0.65689D-03  -0.10877D-02  -0.24120D-01
S1 Engine No:2 +Y-Z               1152     0.24355D-01   0.10815D+00  -0.25034D-02  -0.15014D-04  -0.11062D-02  -0.24793D-01
S1 Engine No:3 -Y-Z               1153    -0.24506D-01   0.10815D+00  -0.27195D-02  -0.53588D-04   0.55393D-04  -0.24804D-01
S1 Engine No:4 -Y-Z               1154    -0.58801D-01   0.10888D+00  -0.22176D-02  -0.57800D-03  -0.14033D-03  -0.24187D-01
S1 Engine No:5 -Y+Z               1155    -0.60141D-01   0.10891D+00  -0.22571D-02   0.46030D-03  -0.11928D-02  -0.24287D-01
S1 Engine No:6 -Y+Z               1156    -0.27393D-01   0.10860D+00  -0.22342D-02  -0.37823D-03  -0.11645D-02  -0.24913D-01
S1 Engine No:7 +Y+Z               1157     0.21590D-01   0.10861D+00  -0.31599D-02  -0.26407D-03  -0.86386D-04  -0.24786D-01
S1 Engine No:8 +Y+Z               1158     0.55859D-01   0.10904D+00  -0.29850D-02   0.48605D-03  -0.83779D-04  -0.24085D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.84179D-03   0.27986D-01  -0.63682D-03  -0.72384D-05   0.13067D-06  -0.41431D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.84179D-03   0.27986D-01  -0.63682D-03  -0.72384D-05   0.13067D-06  -0.41431D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.84179D-03   0.27986D-01  -0.63682D-03  -0.72384D-05   0.13067D-06  -0.41431D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.84179D-03   0.27986D-01  -0.63682D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.84179D-03   0.27986D-01  -0.63682D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.63807D-03   0.85829D-01  -0.18664D-02   0.37943D-04   0.21853D-03   0.10120D-01
Fuel Slosh Mass Locat.             600    -0.96414D-03  -0.11706D+00   0.28595D-02  -0.90719D-04  -0.22572D-03  -0.94360D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.34373D-02   0.68868D-01  -0.23442D-02   0.13640D-01  -0.58948D-03  -0.40824D-02

MODE# 20/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    294.34       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.23772D-01  -0.27909D-02  -0.11227D+00  -0.18738D-03  -0.25378D-01   0.99000D-06
S1 Engine No:2 +Y-Z               1152     0.58903D-01  -0.26484D-02  -0.11264D+00   0.36230D-03  -0.24769D-01   0.10354D-03
S1 Engine No:3 -Y-Z               1153     0.60038D-01  -0.27019D-02  -0.11239D+00  -0.59099D-03  -0.24800D-01   0.10394D-02
S1 Engine No:4 -Y-Z               1154     0.26407D-01  -0.23408D-02  -0.11177D+00   0.65812D-04  -0.25420D-01   0.10761D-02
S1 Engine No:5 -Y+Z               1155    -0.23688D-01  -0.27266D-02  -0.11177D+00   0.48500D-04  -0.25409D-01   0.10094D-04
S1 Engine No:6 -Y+Z               1156    -0.58774D-01  -0.22881D-02  -0.11247D+00  -0.65658D-03  -0.24749D-01   0.35287D-04
S1 Engine No:7 +Y+Z               1157    -0.59831D-01  -0.23227D-02  -0.11270D+00   0.43591D-03  -0.24762D-01   0.10461D-02
S1 Engine No:8 +Y+Z               1158    -0.26262D-01  -0.21453D-02  -0.11227D+00  -0.20538D-03  -0.25400D-01   0.10820D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.23837D-04  -0.68388D-03  -0.28642D-01  -0.55283D-05   0.55571D-05   0.10548D-05
Stage-2 Tank Top, IMU Locat.     40015     0.23837D-04  -0.68388D-03  -0.28642D-01  -0.55283D-05   0.55571D-05   0.10548D-05
Stage-2 Tank Top, IMU Locat.     40015     0.23837D-04  -0.68388D-03  -0.28642D-01  -0.55283D-05   0.55571D-05   0.10548D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.23837D-04  -0.68388D-03  -0.28642D-01
Stage-2 Tank Top, IMU Locat.     40015     0.23837D-04  -0.68388D-03  -0.28642D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.30214D-04  -0.21206D-02  -0.84864D-01   0.27600D-04   0.99186D-02  -0.24962D-03
Fuel Slosh Mass Locat.             600     0.44984D-04   0.26343D-02   0.11948D+00  -0.66486D-04  -0.96832D-02   0.21870D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.15770D-03  -0.54284D-03  -0.57093D-01   0.10143D-01   0.57320D-02  -0.65467D-03

MODE# 21/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    309.47       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.51878D-01  -0.10566D+00   0.18017D-02   0.66030D-03   0.82601D-03   0.21727D-01
S1 Engine No:2 +Y-Z               1152    -0.21989D-01  -0.10495D+00   0.13546D-02  -0.87125D-04   0.85709D-03   0.22673D-01
S1 Engine No:3 -Y-Z               1153     0.22740D-01  -0.10495D+00   0.18332D-02  -0.53500D-04  -0.29923D-03   0.22685D-01
S1 Engine No:4 -Y-Z               1154     0.53601D-01  -0.10563D+00   0.14004D-02   0.56899D-03  -0.84530D-04   0.21790D-01
S1 Engine No:5 -Y+Z               1155     0.54472D-01  -0.10546D+00   0.14236D-02  -0.64346D-03   0.93754D-03   0.21892D-01
S1 Engine No:6 -Y+Z               1156     0.24456D-01  -0.10497D+00   0.12434D-02   0.34226D-03   0.89590D-03   0.22805D-01
S1 Engine No:7 +Y+Z               1157    -0.20427D-01  -0.10498D+00   0.21480D-02   0.21652D-03  -0.16980D-03   0.22682D-01
S1 Engine No:8 +Y+Z               1158    -0.51251D-01  -0.10562D+00   0.17992D-02  -0.67664D-03  -0.16799D-03   0.21698D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.49553D-03   0.23231D-01  -0.45984D-03   0.18936D-05  -0.20062D-05  -0.18534D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.49553D-03   0.23231D-01  -0.45984D-03   0.18936D-05  -0.20062D-05  -0.18534D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.49553D-03   0.23231D-01  -0.45984D-03   0.18936D-05  -0.20062D-05  -0.18534D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.49553D-03   0.23231D-01  -0.45984D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.49553D-03   0.23231D-01  -0.45984D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.47861D-03   0.88781D-01  -0.16619D-02  -0.10924D-04   0.18966D-03   0.10212D-01
Fuel Slosh Mass Locat.             600     0.77698D-03   0.86154D-01  -0.13300D-02   0.30472D-04   0.81148D-04   0.56222D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.40591D-02  -0.68887D-01   0.18308D-02  -0.52792D-02   0.62210D-03   0.50220D-02

MODE# 22/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    310.18       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.20545D-01   0.21905D-02   0.10200D+00   0.14453D-03   0.21746D-01   0.10416D-03
S1 Engine No:2 +Y-Z               1152    -0.50350D-01   0.19376D-02   0.10249D+00  -0.46903D-03   0.20912D-01  -0.40487D-05
S1 Engine No:3 -Y-Z               1153    -0.51193D-01   0.19740D-02   0.10236D+00   0.57882D-03   0.20939D-01  -0.83987D-03
S1 Engine No:4 -Y-Z               1154    -0.22470D-01   0.16755D-02   0.10180D+00  -0.15193D-03   0.21788D-01  -0.87457D-03
S1 Engine No:5 -Y+Z               1155     0.20523D-01   0.22671D-02   0.10180D+00  -0.13265D-03   0.21781D-01   0.99374D-04
S1 Engine No:6 -Y+Z               1156     0.50274D-01   0.18853D-02   0.10245D+00   0.65089D-03   0.20891D-01   0.72846D-04
S1 Engine No:7 +Y+Z               1157     0.51028D-01   0.19013D-02   0.10256D+00  -0.54823D-03   0.20898D-01  -0.84582D-03
S1 Engine No:8 +Y+Z               1158     0.22376D-01   0.16019D-02   0.10201D+00   0.15590D-03   0.21763D-01  -0.88435D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.59653D-05  -0.36866D-03  -0.24558D-01   0.10194D-05  -0.11860D-03   0.31657D-05
Stage-2 Tank Top, IMU Locat.     40015     0.59653D-05  -0.36866D-03  -0.24558D-01   0.10194D-05  -0.11860D-03   0.31657D-05
Stage-2 Tank Top, IMU Locat.     40015     0.59653D-05  -0.36866D-03  -0.24558D-01   0.10194D-05  -0.11860D-03   0.31657D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.59653D-05  -0.36866D-03  -0.24558D-01
Stage-2 Tank Top, IMU Locat.     40015     0.59653D-05  -0.36866D-03  -0.24558D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.16972D-04  -0.14238D-02  -0.89612D-01  -0.77062D-05   0.10181D-01  -0.16300D-03
Fuel Slosh Mass Locat.             600    -0.28908D-04  -0.15444D-02  -0.81676D-01   0.21602D-04   0.53386D-02  -0.10610D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.16037D-03   0.32604D-03   0.54437D-01  -0.38245D-02  -0.39202D-02   0.57396D-03

MODE# 23/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    337.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.56387D-01  -0.96784D-01   0.13343D-02   0.82973D-03   0.11812D-02   0.23969D-01
S1 Engine No:2 +Y-Z               1152    -0.24127D-01  -0.95890D-01   0.77034D-03  -0.15844D-03   0.12764D-02   0.24784D-01
S1 Engine No:3 -Y-Z               1153     0.24505D-01  -0.95893D-01   0.14845D-02  -0.12368D-03  -0.79219D-03   0.24779D-01
S1 Engine No:4 -Y-Z               1154     0.57629D-01  -0.96715D-01   0.96092D-03   0.69166D-03  -0.48176D-03   0.24007D-01
S1 Engine No:5 -Y+Z               1155     0.58502D-01  -0.96376D-01   0.97599D-03  -0.90484D-03   0.13285D-02   0.24155D-01
S1 Engine No:6 -Y+Z               1156     0.26052D-01  -0.95680D-01   0.68336D-03   0.46607D-03   0.12814D-02   0.24973D-01
S1 Engine No:7 +Y+Z               1157    -0.22842D-01  -0.95699D-01   0.18910D-02   0.27955D-03  -0.67769D-03   0.24814D-01
S1 Engine No:8 +Y+Z               1158    -0.55891D-01  -0.96616D-01   0.13482D-02  -0.95849D-03  -0.64254D-03   0.23921D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.40340D-03   0.81295D-02  -0.14084D-03   0.17548D-06  -0.95904D-05  -0.85525D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.40340D-03   0.81295D-02  -0.14084D-03   0.17548D-06  -0.95904D-05  -0.85525D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.40340D-03   0.81295D-02  -0.14084D-03   0.17548D-06  -0.95904D-05  -0.85525D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.40340D-03   0.81295D-02  -0.14084D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.40340D-03   0.81295D-02  -0.14084D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.29347D-03   0.34979D-01  -0.51829D-03  -0.33704D-05   0.10448D-03   0.75610D-02
Fuel Slosh Mass Locat.             600     0.61647D-03   0.10657D+00  -0.13490D-02   0.11708D-04   0.85142D-04   0.70031D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.53284D-02  -0.61715D-01   0.15136D-02  -0.23599D-02   0.64345D-03   0.89486D-02

MODE# 24/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    337.96       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.24195D-01  -0.17083D-02  -0.99521D-01  -0.20356D-03  -0.25441D-01  -0.63943D-03
S1 Engine No:2 +Y-Z               1152     0.58408D-01  -0.13140D-02  -0.10023D+00   0.67661D-03  -0.24714D-01  -0.46810D-03
S1 Engine No:3 -Y-Z               1153     0.59149D-01  -0.13512D-02  -0.10008D+00  -0.78671D-03  -0.24749D-01   0.12072D-02
S1 Engine No:4 -Y-Z               1154     0.25831D-01  -0.96706D-03  -0.99347D-01   0.27899D-03  -0.25511D-01   0.12914D-02
S1 Engine No:5 -Y+Z               1155    -0.24254D-01  -0.19183D-02  -0.99348D-01   0.24528D-03  -0.25495D-01  -0.64555D-03
S1 Engine No:6 -Y+Z               1156    -0.58368D-01  -0.14031D-02  -0.10023D+00  -0.90071D-03  -0.24678D-01  -0.59419D-03
S1 Engine No:7 +Y+Z               1157    -0.58957D-01  -0.14092D-02  -0.10036D+00   0.79685D-03  -0.24686D-01   0.12096D-02
S1 Engine No:8 +Y+Z               1158    -0.25761D-01  -0.91649D-03  -0.99525D-01  -0.19400D-03  -0.25457D-01   0.13145D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.43271D-05   0.10146D-03   0.10522D-01  -0.10107D-07   0.77281D-03  -0.11685D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.43271D-05   0.10146D-03   0.10522D-01  -0.10107D-07   0.77281D-03  -0.11685D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.43271D-05   0.10146D-03   0.10522D-01  -0.10107D-07   0.77281D-03  -0.11685D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.43271D-05   0.10146D-03   0.10522D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.43271D-05   0.10146D-03   0.10522D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.92534D-05   0.44544D-03   0.39055D-01   0.25142D-05  -0.79842D-02   0.98017D-04
Fuel Slosh Mass Locat.             600     0.20561D-04   0.14552D-02   0.10863D+00  -0.88355D-05  -0.71468D-02   0.99295D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.18396D-03   0.62226D-04  -0.51264D-01   0.18402D-02  -0.29898D-03  -0.53983D-03

MODE# 25/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    385.52       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.31775D-01   0.55841D-01  -0.23177D-03  -0.99330D-03  -0.91277D-03  -0.13267D-01
S1 Engine No:2 +Y-Z               1152     0.13834D-01   0.54748D-01   0.56156D-03   0.13716D-03  -0.11139D-02  -0.14515D-01
S1 Engine No:3 -Y-Z               1153    -0.14569D-01   0.54742D-01  -0.29441D-03   0.18383D-03   0.11620D-02  -0.14536D-01
S1 Engine No:4 -Y-Z               1154    -0.32697D-01   0.55595D-01   0.29273D-03  -0.73736D-03   0.72348D-03  -0.13316D-01
S1 Engine No:5 -Y+Z               1155    -0.33188D-01   0.54946D-01   0.36829D-03   0.12098D-02  -0.11610D-02  -0.13490D-01
S1 Engine No:6 -Y+Z               1156    -0.14885D-01   0.54155D-01   0.70556D-03  -0.75176D-03  -0.10412D-02  -0.14910D-01
S1 Engine No:7 +Y+Z               1157     0.14163D-01   0.54194D-01  -0.11486D-02  -0.43295D-03   0.11655D-02  -0.14705D-01
S1 Engine No:8 +Y+Z               1158     0.32030D-01   0.55404D-01  -0.36161D-03   0.13552D-02   0.11162D-02  -0.13214D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.60597D-03  -0.61704D-01   0.60439D-04  -0.11840D-06  -0.53030D-05  -0.50468D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.60597D-03  -0.61704D-01   0.60439D-04  -0.11840D-06  -0.53030D-05  -0.50468D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.60597D-03  -0.61704D-01   0.60439D-04  -0.11840D-06  -0.53030D-05  -0.50468D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.60597D-03  -0.61704D-01   0.60439D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.60597D-03  -0.61704D-01   0.60439D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10456D-03  -0.82181D-01   0.84817D-04   0.60288D-06  -0.69930D-05  -0.74827D-02
Fuel Slosh Mass Locat.             600    -0.35451D-03  -0.37133D-01   0.15300D-04  -0.28380D-05   0.18570D-05  -0.92171D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.52329D-02   0.36272D-01  -0.53039D-03   0.64682D-03  -0.36265D-03  -0.77578D-02

MODE# 26/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    387.47       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.13778D-01  -0.42322D-03  -0.53588D-01  -0.30786D-03  -0.14221D-01  -0.97324D-03
S1 Engine No:2 +Y-Z               1152     0.31654D-01   0.88355D-05  -0.54311D-01   0.76416D-03  -0.13099D-01  -0.75499D-03
S1 Engine No:3 -Y-Z               1153     0.31849D-01   0.60064D-04  -0.54071D-01  -0.95489D-03  -0.13111D-01   0.92814D-03
S1 Engine No:4 -Y-Z               1154     0.14027D-01   0.46323D-03  -0.53309D-01   0.48353D-03  -0.14347D-01   0.10167D-02
S1 Engine No:5 -Y+Z               1155    -0.14053D-01  -0.96288D-03  -0.53324D-01   0.36762D-03  -0.14305D-01  -0.10497D-02
S1 Engine No:6 -Y+Z               1156    -0.31661D-01  -0.28187D-03  -0.54381D-01  -0.11668D-02  -0.13014D-01  -0.10030D-02
S1 Engine No:7 +Y+Z               1157    -0.31529D-01  -0.17682D-03  -0.54634D-01   0.96718D-03  -0.12990D-01   0.89448D-03
S1 Engine No:8 +Y+Z               1158    -0.13992D-01   0.54789D-03  -0.53606D-01  -0.16817D-03  -0.14161D-01   0.10927D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.90431D-06   0.65277D-04   0.60489D-01  -0.88092D-06  -0.51090D-02   0.51674D-05
Stage-2 Tank Top, IMU Locat.     40015     0.90431D-06   0.65277D-04   0.60489D-01  -0.88092D-06  -0.51090D-02   0.51674D-05
Stage-2 Tank Top, IMU Locat.     40015     0.90431D-06   0.65277D-04   0.60489D-01  -0.88092D-06  -0.51090D-02   0.51674D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.90431D-06   0.65277D-04   0.60489D-01
Stage-2 Tank Top, IMU Locat.     40015     0.90431D-06   0.65277D-04   0.60489D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.20265D-05   0.81798D-04   0.79918D-01   0.47393D-06  -0.71575D-02   0.80096D-05
Fuel Slosh Mass Locat.             600     0.65767D-05   0.57695D-04   0.35572D-01  -0.19166D-05  -0.84616D-03   0.34937D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.92716D-04   0.45339D-03  -0.28000D-01   0.47422D-03  -0.24589D-02  -0.34477D-03

MODE# 27/ 39, Frequency (rad/sec), Damping (zeta), Generalized Mass=    439.31       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.60352D-01  -0.53403D-01   0.90514D-02  -0.62190D-01  -0.46085D-01   0.62959D-01
S1 Engine No:2 +Y-Z               1152     0.24265D-01  -0.99933D-01   0.40792D-01   0.30581D-01  -0.45670D-01  -0.30838D-01
S1 Engine No:3 -Y-Z               1153    -0.25852D-01  -0.98592D-01  -0.45239D-01   0.18756D-01   0.54979D-01  -0.22382D-01
S1 Engine No:4 -Y-Z               1154     0.71183D-01  -0.45189D-01  -0.38456D-02  -0.56861D-01   0.36422D-01   0.73276D-01
S1 Engine No:5 -Y+Z               1155     0.61540D-01  -0.54822D-01   0.10052D-01   0.62700D-01  -0.46438D-01   0.63005D-01
S1 Engine No:6 -Y+Z               1156    -0.22690D-01  -0.10109D+00   0.41247D-01  -0.31657D-01  -0.45480D-01  -0.31555D-01
S1 Engine No:7 +Y+Z               1157     0.28865D-01  -0.99660D-01  -0.46767D-01  -0.19214D-01   0.55534D-01  -0.22961D-01
S1 Engine No:8 +Y+Z               1158    -0.68793D-01  -0.45514D-01  -0.49074D-02   0.57911D-01   0.37180D-01   0.73321D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.80128D-05  -0.38095D-01   0.49055D-04   0.83466D-07  -0.37267D-05  -0.28789D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.80128D-05  -0.38095D-01   0.49055D-04   0.83466D-07  -0.37267D-05  -0.28789D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.80128D-05  -0.38095D-01   0.49055D-04   0.83466D-07  -0.37267D-05  -0.28789D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.80128D-05  -0.38095D-01   0.49055D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.80128D-05  -0.38095D-01   0.49055D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.18159D-03   0.83479D-01  -0.10708D-03  -0.38419D-06   0.30354D-05   0.23764D-02
Fuel Slosh Mass Locat.             600     0.76171D-03   0.13996D-01  -0.20750D-04   0.22506D-05  -0.46171D-05  -0.31026D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.14979D-01  -0.49913D-01   0.77587D-03  -0.54914D-03   0.50672D-03   0.15749D-01

MODE# 28/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    439.41       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.13680D-01   0.31860D-01  -0.94517D-01   0.19100D-01   0.15143D-01   0.37232D-01
S1 Engine No:2 +Y-Z               1152     0.60945D-01   0.49731D-02  -0.57520D-01  -0.44713D-01  -0.55950D-01   0.31093D-01
S1 Engine No:3 -Y-Z               1153     0.61243D-01  -0.54974D-02  -0.57429D-01   0.44778D-01  -0.56507D-01  -0.30752D-01
S1 Engine No:4 -Y-Z               1154    -0.13968D-01  -0.32886D-01  -0.94897D-01  -0.18785D-01   0.14956D-01  -0.37722D-01
S1 Engine No:5 -Y+Z               1155     0.14215D-01   0.32727D-01  -0.94927D-01  -0.19097D-01   0.15220D-01   0.37463D-01
S1 Engine No:6 -Y+Z               1156    -0.60856D-01   0.54505D-02  -0.57455D-01   0.45202D-01  -0.56074D-01   0.31394D-01
S1 Engine No:7 +Y+Z               1157    -0.61691D-01  -0.50594D-02  -0.56602D-01  -0.44604D-01  -0.56634D-01  -0.30559D-01
S1 Engine No:8 +Y+Z               1158     0.13923D-01  -0.32931D-01  -0.94400D-01   0.18112D-01   0.14507D-01  -0.37864D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.38818D-06  -0.74307D-04  -0.38181D-01  -0.34032D-07   0.29086D-02  -0.56315D-05
Stage-2 Tank Top, IMU Locat.     40015     0.38818D-06  -0.74307D-04  -0.38181D-01  -0.34032D-07   0.29086D-02  -0.56315D-05
Stage-2 Tank Top, IMU Locat.     40015     0.38818D-06  -0.74307D-04  -0.38181D-01  -0.34032D-07   0.29086D-02  -0.56315D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.38818D-06  -0.74307D-04  -0.38181D-01
Stage-2 Tank Top, IMU Locat.     40015     0.38818D-06  -0.74307D-04  -0.38181D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.29530D-05   0.16354D-03   0.83688D-01   0.24462D-06  -0.23940D-02   0.46892D-05
Fuel Slosh Mass Locat.             600     0.12244D-04   0.26757D-04   0.14488D-01  -0.14618D-05   0.30456D-02  -0.55716D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.23673D-03   0.64612D-03  -0.37009D-01   0.39534D-03  -0.66514D-02  -0.47820D-03

MODE# 29/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    471.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.12117D-01  -0.20441D-01  -0.24644D-03   0.22837D-02   0.17688D-02   0.40231D-02
S1 Engine No:2 +Y-Z               1152    -0.68031D-02  -0.18498D-01  -0.16079D-02  -0.90264D-03   0.22556D-02   0.74856D-02
S1 Engine No:3 -Y-Z               1153     0.77547D-02  -0.18491D-01   0.15900D-02  -0.98660D-03  -0.22886D-02   0.76000D-02
S1 Engine No:4 -Y-Z               1154     0.13105D-01  -0.20442D-01   0.25370D-03   0.23822D-02  -0.19478D-02   0.41969D-02
S1 Engine No:5 -Y+Z               1155     0.12967D-01  -0.20574D-01  -0.18550D-03  -0.22684D-02   0.17981D-02   0.41195D-02
S1 Engine No:6 -Y+Z               1156     0.76901D-02  -0.18595D-01  -0.15995D-02   0.80090D-03   0.23291D-02   0.74382D-02
S1 Engine No:7 +Y+Z               1157    -0.67197D-02  -0.18573D-01   0.14189D-02   0.97621D-03  -0.21098D-02   0.75113D-02
S1 Engine No:8 +Y+Z               1158    -0.12196D-01  -0.20398D-01   0.18564D-03  -0.22793D-02  -0.18538D-02   0.41716D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.11160D-03  -0.22393D-01  -0.22246D-04   0.21158D-07  -0.71522D-05   0.72046D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.11160D-03  -0.22393D-01  -0.22246D-04   0.21158D-07  -0.71522D-05   0.72046D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.11160D-03  -0.22393D-01  -0.22246D-04   0.21158D-07  -0.71522D-05   0.72046D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.11160D-03  -0.22393D-01  -0.22246D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.11160D-03  -0.22393D-01  -0.22246D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.56391D-04   0.69080D-02   0.51688D-05  -0.77910D-07   0.17327D-05  -0.16624D-02
Fuel Slosh Mass Locat.             600     0.33500D-03  -0.27509D-02  -0.58693D-05   0.48871D-06   0.18034D-05  -0.18448D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.86458D-02  -0.12607D-01   0.16632D-03  -0.12190D-03   0.11414D-03   0.54878D-02

MODE# 30/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    471.62       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.75464D-02  -0.17973D-02  -0.18685D-01  -0.10066D-02  -0.77633D-02  -0.25447D-02
S1 Engine No:2 +Y-Z               1152     0.12575D-01  -0.24294D-03  -0.20891D-01   0.26063D-02  -0.38915D-02  -0.20521D-02
S1 Engine No:3 -Y-Z               1153     0.12563D-01   0.25812D-03  -0.20896D-01  -0.25925D-02  -0.39096D-02   0.20383D-02
S1 Engine No:4 -Y-Z               1154     0.74965D-02   0.18005D-02  -0.18707D-01   0.99700D-03  -0.77507D-02   0.25134D-02
S1 Engine No:5 -Y+Z               1155    -0.74823D-02  -0.17012D-02  -0.18699D-01   0.10613D-02  -0.77897D-02  -0.24967D-02
S1 Engine No:6 -Y+Z               1156    -0.12589D-01  -0.22024D-03  -0.20837D-01  -0.25825D-02  -0.39148D-02  -0.20455D-02
S1 Engine No:7 +Y+Z               1157    -0.12598D-01   0.27963D-03  -0.20814D-01   0.26058D-02  -0.39174D-02   0.20567D-02
S1 Engine No:8 +Y+Z               1158    -0.74706D-02   0.17530D-02  -0.18675D-01  -0.10888D-02  -0.78136D-02   0.24828D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.26093D-06   0.22596D-04  -0.22665D-01   0.27721D-06  -0.71621D-02  -0.71461D-05
Stage-2 Tank Top, IMU Locat.     40015     0.26093D-06   0.22596D-04  -0.22665D-01   0.27721D-06  -0.71621D-02  -0.71461D-05
Stage-2 Tank Top, IMU Locat.     40015     0.26093D-06   0.22596D-04  -0.22665D-01   0.27721D-06  -0.71621D-02  -0.71461D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.26093D-06   0.22596D-04  -0.22665D-01
Stage-2 Tank Top, IMU Locat.     40015     0.26093D-06   0.22596D-04  -0.22665D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.88888D-06  -0.85352D-05   0.68877D-02  -0.62658D-07   0.16628D-02   0.15733D-05
Fuel Slosh Mass Locat.             600     0.40352D-05   0.10316D-06  -0.26919D-02  -0.26365D-06   0.18350D-02   0.17503D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.83524D-04   0.19351D-03  -0.76774D-02   0.73546D-04  -0.21245D-02  -0.12632D-03

MODE# 31/ 58, Frequency (rad/sec), Damping (zeta), Generalized Mass=    605.41       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.42754D-01   0.43475D-01   0.60908D-02   0.84767D-03   0.17237D-02  -0.23028D-01
S1 Engine No:2 +Y-Z               1152     0.12114D-01   0.43866D-01   0.55733D-02  -0.18785D-03   0.10994D-02  -0.19705D-01
S1 Engine No:3 -Y-Z               1153    -0.25278D-01   0.43932D-01   0.67447D-02  -0.42906D-03   0.57282D-02  -0.20140D-01
S1 Engine No:4 -Y-Z               1154    -0.48192D-01   0.43761D-01   0.63845D-02   0.92194D-03   0.42072D-02  -0.23911D-01
S1 Engine No:5 -Y+Z               1155    -0.42679D-01   0.43625D-01   0.58024D-02  -0.13564D-02   0.18499D-02  -0.23894D-01
S1 Engine No:6 -Y+Z               1156    -0.11324D-01   0.44533D-01   0.49643D-02   0.85241D-03   0.20767D-02  -0.18668D-01
S1 Engine No:7 +Y+Z               1157     0.24404D-01   0.44529D-01   0.77702D-02   0.45881D-03   0.43172D-02  -0.19530D-01
S1 Engine No:8 +Y+Z               1158     0.48486D-01   0.43550D-01   0.66390D-02  -0.11567D-02   0.43808D-02  -0.24857D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.77513D-05  -0.19076D-01  -0.27954D-02  -0.22542D-07  -0.25064D-03   0.17122D-02
Stage-2 Tank Top, IMU Locat.     40015     0.77513D-05  -0.19076D-01  -0.27954D-02  -0.22542D-07  -0.25064D-03   0.17122D-02
Stage-2 Tank Top, IMU Locat.     40015     0.77513D-05  -0.19076D-01  -0.27954D-02  -0.22542D-07  -0.25064D-03   0.17122D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.77513D-05  -0.19076D-01  -0.27954D-02
Stage-2 Tank Top, IMU Locat.     40015     0.77513D-05  -0.19076D-01  -0.27954D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.11725D-04   0.12143D+00   0.17791D-01  -0.94648D-07  -0.24072D-03   0.16426D-02
Fuel Slosh Mass Locat.             600     0.32794D-04   0.16305D+00   0.23883D-01   0.11172D-05  -0.25530D-02   0.17416D-01

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.14467D-01  -0.73611D-01  -0.68919D-02  -0.12949D-03  -0.10899D-02   0.24400D-01

MODE# 32/ 59, Frequency (rad/sec), Damping (zeta), Generalized Mass=    605.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.25603D-01   0.73612D-02  -0.44451D-01   0.84090D-03  -0.19852D-01  -0.57848D-02
S1 Engine No:2 +Y-Z               1152     0.48597D-01   0.69844D-02  -0.44121D-01  -0.11549D-02  -0.24210D-01  -0.42292D-02
S1 Engine No:3 -Y-Z               1153     0.42911D-01   0.63569D-02  -0.44033D-01   0.12389D-02  -0.23736D-01  -0.18487D-02
S1 Engine No:4 -Y-Z               1154     0.11596D-01   0.57898D-02  -0.44654D-01  -0.73477D-03  -0.19236D-01  -0.15642D-02
S1 Engine No:5 -Y+Z               1155    -0.25261D-01   0.78035D-02  -0.44666D-01  -0.37609D-03  -0.20154D-01  -0.53712D-02
S1 Engine No:6 -Y+Z               1156    -0.48485D-01   0.72028D-02  -0.44223D-01   0.94456D-03  -0.24109D-01  -0.44002D-02
S1 Engine No:7 +Y+Z               1157    -0.43213D-01   0.66888D-02  -0.43661D-01  -0.51491D-03  -0.23690D-01  -0.11903D-02
S1 Engine No:8 +Y+Z               1158    -0.11705D-01   0.58421D-02  -0.44284D-01  -0.19540D-03  -0.20026D-01  -0.18204D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.10975D-05  -0.28601D-02   0.19236D-01  -0.20155D-07   0.17200D-02   0.25598D-03
Stage-2 Tank Top, IMU Locat.     40015     0.10975D-05  -0.28601D-02   0.19236D-01  -0.20155D-07   0.17200D-02   0.25598D-03
Stage-2 Tank Top, IMU Locat.     40015     0.10975D-05  -0.28601D-02   0.19236D-01  -0.20155D-07   0.17200D-02   0.25598D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.10975D-05  -0.28601D-02   0.19236D-01
Stage-2 Tank Top, IMU Locat.     40015     0.10975D-05  -0.28601D-02   0.19236D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.17931D-05   0.18189D-01  -0.12230D+00   0.30041D-07   0.16391D-02   0.24361D-03
Fuel Slosh Mass Locat.             600     0.54840D-05   0.24386D-01  -0.16389D+00  -0.42785D-07   0.17531D-01   0.26044D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.22458D-02  -0.12785D-01   0.59979D-01  -0.16573D-03   0.15803D-01   0.48230D-02
----------------------------------------------------------------------------------------------------------------------------
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
