BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=30 sec
! This batch set creates dynamic models for Control Analysis at T=30 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
! --------------   Create Vehicle, TVC and Actuator Models  ------------
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=30.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=30.0 sec 
Actuator Model   : Stage-1 Linear Actuator
System Connection: System of 8 TVC Actuators
!
! --------------   Build the Flight Control System  ---------------------
Transf-Function  : Integrator
Transf-Function  : Alpha Estimator
Transf-Function  : Beta Estimator
Transf-Function  : Low Pass Filters
System Connection: Flight Control System 
!
!  -------------   Create Plant Models  ---------------------------------
System Connection: Plant Model at T=30 sec, Vehicle/ Actuators
System Connection: Closed-Loop System
System Connection: Open-Loop System
System Connection: Roll Loop Opened, Others Closed
System Connection: Pitch Loop Opened, Others Closed
System Connection: Yaw Loop Opened, Others Closed
!
!  -------------   Export to Matlab  -----------------------------------
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=30.0 sec            
To Matlab Format : Plant Model at T=30 sec, Vehicle/ Actuators
To Matlab Format : Mixing Logic for First Stage Model, at T=30.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
To Matlab Format : Flight Control System
To Matlab Format : Closed-Loop System
To Matlab Format : Open-Loop System
To Matlab Format : Roll Loop Opened, Others Closed
To Matlab Format : Pitch Loop Opened, Others Closed
To Matlab Format : Yaw Loop Opened, Others Closed
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=30.0 sec                                       
! This is a Launch Vehicle Control Analysis Model at t=30 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 100% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.015 
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   4618.67       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   33767.8      0.272623E+07  0.272527E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   57.4827       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.2630        296.760       88.9000       4003.85    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   13.0          45.07         0.0          -0.106    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   1.18000       0.0          -0.04         -0.0
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          87.78         0.00000       0.0          -0.236        -0.0
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       90.0000                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.415        7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.451       -0.00194        0.8315e-4     0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  -0.0         -0.0356         0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.0397      -0.0356         0.00000       0.00000       0.00000       0.00000      -0.1033e-3    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000      0.00000        0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.165        0.1113         0.00000      -0.00000       0.00000      -0.00166       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0         -0.1113         0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945       -1.0332     
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332       -2.4945 
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332       -2.4945
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945       -1.0332 
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945        1.0332
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332        2.4945
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332        2.4945
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945        1.0332 

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438    0.000      0.000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438    0.000      0.000    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438    0.000      0.000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000       

Number of Slosh Modes                                                                    :  2
LOX Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   441.7   3.11   3.11   0.015  0.015  67.68   0.0  0.0  
LH2 Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   151.9   3.11   3.11   0.01   0.01   37.94   0.0  0.0 

Number of Bending Modes                                                                  : 31
First Stage Flex Modes at 80% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=30.0 sec 
! Thrust Vector Control Matrix at t=30 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=30.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
System of 8 TVC Actuators
! Combination of 8 TVC Actuators in Parallel
Titles of Systems to be Combined
Title 1 Stage-1 Linear Actuator 
Title 2 Stage-1 Linear Actuator 
Title 3 Stage-1 Linear Actuator 
Title 4 Stage-1 Linear Actuator 
Title 5 Stage-1 Linear Actuator 
Title 6 Stage-1 Linear Actuator 
Title 7 Stage-1 Linear Actuator 
Title 8 Stage-1 Linear Actuator 
SYSTEM INPUTS TO SUBSYSTEM  1                                                           Engine # 1
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                Command Input
System Input  9 to Subsystem  1, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                           Engine # 2
System Input  2 to Subsystem  2, Input  1, Gain= 1.00000                                Command Input
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                           Engine # 3
System Input  3 to Subsystem  3, Input  1, Gain= 1.00000                                Command Input
System Input 11 to Subsystem  3, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                           Engine # 4
System Input  4 to Subsystem  4, Input  1, Gain= 1.00000                                Command Input
System Input 12 to Subsystem  4, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                           Engine # 5
System Input  5 to Subsystem  5, Input  1, Gain= 1.00000                                Command Input
System Input 13 to Subsystem  5, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  6                                                           Engine # 6
System Input  6 to Subsystem  6, Input  1, Gain= 1.00000                                Command Input
System Input 14 to Subsystem  6, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  7                                                           Engine # 7
System Input  7 to Subsystem  7, Input  1, Gain= 1.00000                                Command Input
System Input 15 to Subsystem  7, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  8                                                           Engine # 8
System Input  8 to Subsystem  8, Input  1, Gain= 1.00000                                Command Input
System Input 16 to Subsystem  8, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                        Engine # 1
System Output  1 from Subsystem  1, Output  1, Gain= 1.00000                            Deflection
System Output  9 from Subsystem  1, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                        Engine # 2
System Output  2 from Subsystem  2, Output  1, Gain= 1.00000                            Deflection
System Output 10 from Subsystem  2, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                        Engine # 3
System Output  3 from Subsystem  3, Output  1, Gain= 1.00000                            Deflection
System Output 11 from Subsystem  3, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                        Engine # 4
System Output  4 from Subsystem  4, Output  1, Gain= 1.00000                            Deflection
System Output 12 from Subsystem  4, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5                                                        Engine # 5
System Output  5 from Subsystem  5, Output  1, Gain= 1.00000                            Deflection
System Output 13 from Subsystem  5, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  6                                                        Engine # 6
System Output  6 from Subsystem  6, Output  1, Gain= 1.00000                            Deflection
System Output 14 from Subsystem  6, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  7                                                        Engine # 7
System Output  7 from Subsystem  7, Output  1, Gain= 1.00000                            Deflection
System Output 15 from Subsystem  7, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  8                                                        Engine # 8
System Output  8 from Subsystem  8, Output  1, Gain= 1.00000                            Deflection
System Output 16 from Subsystem  8, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
Definitions of Inputs  =  16
Engine # 1 delta command (rad)   
Engine # 2 delta command (rad)                                                              
Engine # 3 delta command (rad)                                                              
Engine # 4 delta command (rad)                                                              
Engine # 5 delta command (rad)                                                              
Engine # 6 delta command (rad)                                                              
Engine # 7 delta command (rad)                                                              
Engine # 8 delta command (rad)                                                              
Engine # 1 Load-Torque (ft-lb)    
Engine # 2 Load-Torque (ft-lb)    
Engine # 3 Load-Torque (ft-lb)    
Engine # 4 Load-Torque (ft-lb)    
Engine # 5 Load-Torque (ft-lb)    
Engine # 6 Load-Torque (ft-lb)    
Engine # 7 Load-Torque (ft-lb)    
Engine # 8 Load-Torque (ft-lb)    
 
Definitions of Outputs =  16
Engine # 1 deflection (rad)   
Engine # 2 deflection (rad)   
Engine # 3 deflection (rad)   
Engine # 4 deflection (rad)   
Engine # 5 deflection (rad)   
Engine # 6 deflection (rad)   
Engine # 7 deflection (rad)   
Engine # 8 deflection (rad)   
Engine # 1 accelerat. (rad/sec^2)   
Engine # 2 accelerat. (rad/sec^2)   
Engine # 3 accelerat. (rad/sec^2)   
Engine # 4 accelerat. (rad/sec^2)   
Engine # 5 accelerat. (rad/sec^2)   
Engine # 6 accelerat. (rad/sec^2)   
Engine # 7 accelerat. (rad/sec^2)   
Engine # 8 accelerat. (rad/sec^2)   
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Plant Model at T=30 sec, Vehicle/ Actuators
! Combines the Vehicle with the 8 Pitch and 8 Yaw Actuators
!
Titles of Systems to be Combined
Title 1 Launch Vehicle First Stage Analysis Model, T=30.0 sec                                                    
Title 2 System of 8 TVC Actuators              
Title 3 System of 8 TVC Actuators           
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   To Pitch Actuators (1-8)
System Input  1 to Subsystem  2, Input  1, Gain= 1.00000            
System Input  2 to Subsystem  2, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  2, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  2, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  2, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  2, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  2, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  2, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   To Yaw Actuators (1-8)
System Input  9 to Subsystem  3, Input  1, Gain= 1.00000            
System Input 10 to Subsystem  3, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  3, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  3, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  3, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  3, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  3, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  3, Input  8, Gain= 1.00000            
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  1                                                                  
System Input 17 to Subsystem  1, Input 33, Gain= 1.0                                            Wind-Gust
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                         Pitch Actuat to Vehicle 
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                    delta_y1  Pitch Engine Deflects  
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                    delta_y2
Subsystem  2, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                    delta_y3
Subsystem  2, Output  4 to Subsystem  1, Input  4, Gain= 1.0                                    delta_y4
Subsystem  2, Output  5 to Subsystem  1, Input  5, Gain= 1.0                                    delta_y5
Subsystem  2, Output  6 to Subsystem  1, Input  6, Gain= 1.0                                    delta_y6
Subsystem  2, Output  7 to Subsystem  1, Input  7, Gain= 1.0                                    delta_y7
Subsystem  2, Output  8 to Subsystem  1, Input  8, Gain= 1.0                                    delta_y8
Subsystem  2, Output  9 to Subsystem  1, Input  9, Gain= 1.0                                    dy1_dd    Engine Accels
Subsystem  2, Output 10 to Subsystem  1, Input 10, Gain= 1.0                                    dy2_dd
Subsystem  2, Output 11 to Subsystem  1, Input 11, Gain= 1.0                                    dy3_dd
Subsystem  2, Output 12 to Subsystem  1, Input 12, Gain= 1.0                                    dy4_dd
Subsystem  2, Output 13 to Subsystem  1, Input 13, Gain= 1.0                                    dy5_dd
Subsystem  2, Output 14 to Subsystem  1, Input 14, Gain= 1.0                                    dy6_dd
Subsystem  2, Output 15 to Subsystem  1, Input 15, Gain= 1.0                                    dy7_dd
Subsystem  2, Output 16 to Subsystem  1, Input 16, Gain= 1.0                                    dy8_dd
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                                                         Yaw Actuat to Vehicle 
Subsystem  3, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                    delta_z1  Yaw Engine Deflects
Subsystem  3, Output  2 to Subsystem  1, Input 18, Gain= 1.0                                    delta_z2
Subsystem  3, Output  3 to Subsystem  1, Input 19, Gain= 1.0                                    delta_z3
Subsystem  3, Output  4 to Subsystem  1, Input 20, Gain= 1.0                                    delta_z4
Subsystem  3, Output  5 to Subsystem  1, Input 21, Gain= 1.0                                    delta_z5
Subsystem  3, Output  6 to Subsystem  1, Input 22, Gain= 1.0                                    delta_z6
Subsystem  3, Output  7 to Subsystem  1, Input 23, Gain= 1.0                                    delta_z7
Subsystem  3, Output  8 to Subsystem  1, Input 24, Gain= 1.0                                    delta_z8
Subsystem  3, Output  9 to Subsystem  1, Input 25, Gain= 1.0                                    dz1_dd    Yaw Engine Accels
Subsystem  3, Output 10 to Subsystem  1, Input 26, Gain= 1.0                                    dz2_dd
Subsystem  3, Output 11 to Subsystem  1, Input 27, Gain= 1.0                                    dz3_dd
Subsystem  3, Output 12 to Subsystem  1, Input 28, Gain= 1.0                                    dz4_dd
Subsystem  3, Output 13 to Subsystem  1, Input 29, Gain= 1.0                                    dz5_dd
Subsystem  3, Output 14 to Subsystem  1, Input 30, Gain= 1.0                                    dz6_dd
Subsystem  3, Output 15 to Subsystem  1, Input 31, Gain= 1.0                                    dz7_dd
Subsystem  3, Output 16 to Subsystem  1, Input 32, Gain= 1.0                                    dz8_dd
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                         Load-Torq TLY to Pitch Actuat 
Subsystem  1, Output 17 to Subsystem  2, Input  9, Gain= 1.0                                    TL_y1
Subsystem  1, Output 18 to Subsystem  2, Input 10, Gain= 1.0                                    TL_y2
Subsystem  1, Output 19 to Subsystem  2, Input 11, Gain= 1.0                                    TL_y3
Subsystem  1, Output 20 to Subsystem  2, Input 12, Gain= 1.0                                    TL_y4
Subsystem  1, Output 21 to Subsystem  2, Input 13, Gain= 1.0                                    TL_y5
Subsystem  1, Output 22 to Subsystem  2, Input 14, Gain= 1.0                                    TL_y6
Subsystem  1, Output 23 to Subsystem  2, Input 15, Gain= 1.0                                    TL_y7
Subsystem  1, Output 24 to Subsystem  2, Input 16, Gain= 1.0                                    TL_y8
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Load-Torq TLZ to Yaw Actuators
Subsystem  1, Output 25 to Subsystem  3, Input  9, Gain= 1.0                                    TL_z1
Subsystem  1, Output 26 to Subsystem  3, Input 10, Gain= 1.0                                    TL_z2
Subsystem  1, Output 27 to Subsystem  3, Input 11, Gain= 1.0                                    TL_z3
Subsystem  1, Output 28 to Subsystem  3, Input 12, Gain= 1.0                                    TL_z4
Subsystem  1, Output 29 to Subsystem  3, Input 13, Gain= 1.0                                    TL_z5
Subsystem  1, Output 30 to Subsystem  3, Input 14, Gain= 1.0                                    TL_z6
Subsystem  1, Output 31 to Subsystem  3, Input 15, Gain= 1.0                                    TL_z7
Subsystem  1, Output 32 to Subsystem  3, Input 16, Gain= 1.0                                    TL_z8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                Vehicle Outputs
Via Matrix +I16                                                                     
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                Pitch Gimbal Deflects
System Output 17 from Subsystem  2, Output  1, Gain= 1.0                                        dy-1
System Output 18 from Subsystem  2, Output  2, Gain= 1.0                                        dy-2
System Output 19 from Subsystem  2, Output  3, Gain= 1.0                                        dy-3
System Output 20 from Subsystem  2, Output  4, Gain= 1.0                                        dy-4
System Output 21 from Subsystem  2, Output  5, Gain= 1.0                                        dy-5
System Output 22 from Subsystem  2, Output  6, Gain= 1.0                                        dy-6
System Output 23 from Subsystem  2, Output  7, Gain= 1.0                                        dy-7
System Output 24 from Subsystem  2, Output  8, Gain= 1.0                                        dy-8
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                Yaw Gimbal Deflects
System Output 25 from Subsystem  3, Output  1, Gain= 1.0                                        dz-1
System Output 26 from Subsystem  3, Output  2, Gain= 1.0                                        dz-2
System Output 27 from Subsystem  3, Output  3, Gain= 1.0                                        dz-3
System Output 28 from Subsystem  3, Output  4, Gain= 1.0                                        dz-4
System Output 29 from Subsystem  3, Output  5, Gain= 1.0                                        dz-5
System Output 30 from Subsystem  3, Output  6, Gain= 1.0                                        dz-6
System Output 31 from Subsystem  3, Output  7, Gain= 1.0                                        dz-7
System Output 32 from Subsystem  3, Output  8, Gain= 1.0                                        dz-8
..............................................................................
Definitions of Inputs  =  17
Engine Pitch Deflect Comd delta y_1 (rad)   
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)   
Wind-Gust Velocity (ft/sec)
 
Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Alpha Estimator
Continuous
TF. Block #  1 Nz-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Alfa Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at 4.38 (rad)                          Order of Numer, Denom=  2  2
Numer 1.0         0.064       13.838
Denom 1.0         1.28        13.838
......................................................
Block #, from Input #, Gain
 2       1    -23120.0                                           Eng #1 Dy
 2       2    -23120.0                                           Eng #2 Dy
 2       3    -23120.0                                           Eng #3 Dy
 2       4    -23120.0                                           Eng #4 Dy
 2       5    -23120.0                                           Eng #5 Dy
 2       6    -23120.0                                           Eng #6 Dy
 2       7    -23120.0                                           Eng #7 Dy
 2       8    -23120.0                                           Eng #8 Dy
 1       9     20.0                                              Pitch Rate q
 2      10    -4618.67                                           Zdd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    -4618.67                                           Vehi Mass
 2       3    -140.6                                             Qbar.Sref.Cza
 3       2     0.0015                                            Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (deg2rad)
............................
Definitions of Inputs  =  10
Engine # 1 DY Deflection in (rad)
Engine # 2 DY Deflection in (rad)
Engine # 3 DY Deflection in (rad)
Engine # 4 DY Deflection in (rad)
Engine # 5 DY Deflection in (rad)
Engine # 6 DY Deflection in (rad)
Engine # 7 DY Deflection in (rad)
Engine # 8 DY Deflection in (rad)
Vehicle Pitch Rate      (rad/sec)                                            
Normal  Accelerat. Nz (ft/sec^2)                                                
 
Definitions of Outputs =   1
Alpha Estimate in (rad)
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Beta Estimator
Continuous
TF. Block #  1 Ny-Different.                                     Order of Numer, Denom=  1  1
Numer 1.0         0.0         
Denom 0.015       1.0  
TF. Block #  2 Beta Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0         
Denom 1.0         0.0  
TF. Block #  3 Slsh-Notch at 4.38 (rad)                          Order of Numer, Denom=  2  2
Numer 1.0         0.064       13.838
Denom 1.0         1.28        13.838
......................................................
Block #, from Input #, Gain
 2       1     23120.0                                           Eng #1 Dz
 2       2     23120.0                                           Eng #2 Dz
 2       3     23120.0                                           Eng #3 Dz
 2       4     23120.0                                           Eng #4 Dz
 2       5     23120.0                                           Eng #5 Dz
 2       6     23120.0                                           Eng #6 Dz
 2       7     23120.0                                           Eng #7 Dz
 2       8     23120.0                                           Eng #8 Dz
 1       9     20.0                                              Yaw Rate r
 2      10    -4618.67                                           Ydd, V.Mass
...........................
Block #, from Block #, Gain
 2       1    +4618.67                                           Vehi Mass
 2       3    -140.6                                             Qbar.Sref.Cyb
 3       2     0.0015                                            Estimator Gain
...........................
Outpt #, from Block #, Gain
 1       3     0.0175                                            Alpha Estimate (deg2rad)
............................
Definitions of Inputs  =  10
Engine # 1 DZ Deflection in (rad)
Engine # 2 DZ Deflection in (rad)
Engine # 3 DZ Deflection in (rad)
Engine # 4 DZ Deflection in (rad)
Engine # 5 DZ Deflection in (rad)
Engine # 6 DZ Deflection in (rad)
Engine # 7 DZ Deflection in (rad)
Engine # 8 DZ Deflection in (rad)
Vehicle Yaw Rate      (rad/sec)                                            
Lateral Accelerat. Ny (ft/sec^2)                                                
 
Definitions of Outputs =   1
Beta Estimate in (rad)
---------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Integrator
Continuous
TF. Block #  1    1/s                                            Order of Numer, Denom=  0  1
Numer 0.0         1.0      
Denom 1.0         0.0      
......................................................
Block #, from Input #, Gain
  1  1    1.0                             
...........................
Outpt #, from Block #, Gain
  1  1    1.0
...........................
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Low Pass Filters
Continuous
TF. Block #  1 Roll Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         900.0
Denom 1.0         39.0        900.0
TF. Block #  2 Ptch Low-Pass                                     Order of Numer, Denom=  0  2
Numer 0.0         0.0         324.0
Denom 1.0         23.5        324.0
TF. Block #  3 Yaw Low-Pass                                      Order of Numer, Denom=  0  2
Numer 0.0         0.0         324.0
Denom 1.0         23.5        324.0
TF. Block #  4 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  5 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
TF. Block #  6 Delay (sec)= 0.02                                 Order of Numer, Denom=  1  2
......................................................
Block #, from Input #, Gain
 1       1        1.0                                            
 2       2        1.0                                            
 3       3        1.0                                            
...........................
Block #, from Block #, Gain
 4       1        1.0                                 
 5       2        1.0                                 
 6       3        1.0                                 
............................
Outpt #, from Block #, Gain
 1       4        1.0                                            DP_TVC
 2       5        1.0                                            DQ_TVC
 3       6        1.0                                            DR_TVC
............................
Definitions of Inputs  =   3
Roll   Filter Input
Pitch  Filter Input
Yaw    Filter Input
 
Definitions of Outputs =   3
Roll   Filter Output DP_tvc
Pitch  Filter Output DQ_tvc
Yaw    Filter Output DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Flight Control System
! Combine the Filters, Gains and Alpha/Beta Estimators. The Controller
! in Pitch  uses state-feedback from: [Theta, q, Alpha, Theta_Integral]
! in Yaw it uses state-feedback from: [Psi,   r, Beta,  & Psi_Integral]
!
Titles of Systems to be Combined
Title 1 Alpha Estimator
Title 2 Beta Estimator
Title 3 Low Pass Filters
Title 4 Integrator
Title 5 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                                   to Alfa Estimator
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                        Pitch Gimbal Deflects DY (1-8)
System Input  2 to Subsystem  1, Input  2, Gain= 1.00000            
System Input  3 to Subsystem  1, Input  3, Gain= 1.00000            
System Input  4 to Subsystem  1, Input  4, Gain= 1.00000            
System Input  5 to Subsystem  1, Input  5, Gain= 1.00000            
System Input  6 to Subsystem  1, Input  6, Gain= 1.00000            
System Input  7 to Subsystem  1, Input  7, Gain= 1.00000            
System Input  8 to Subsystem  1, Input  8, Gain= 1.00000            
System Input 21 to Subsystem  1, Input  9, Gain= 1.00000                                        Pitch Rate Q
System Input 23 to Subsystem  1, Input 10, Gain= 1.00000                                        NZ Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                   to Beta Estimator
System Input  9 to Subsystem  2, Input  1, Gain= 1.00000                                        Yaw Gimbal Deflects DZ (1-8)
System Input 10 to Subsystem  2, Input  2, Gain= 1.00000            
System Input 11 to Subsystem  2, Input  3, Gain= 1.00000            
System Input 12 to Subsystem  2, Input  4, Gain= 1.00000            
System Input 13 to Subsystem  2, Input  5, Gain= 1.00000            
System Input 14 to Subsystem  2, Input  6, Gain= 1.00000            
System Input 15 to Subsystem  2, Input  7, Gain= 1.00000            
System Input 16 to Subsystem  2, Input  8, Gain= 1.00000            
System Input 22 to Subsystem  2, Input  9, Gain= 1.00000                                        Yaw Rate R
System Input 24 to Subsystem  2, Input 10, Gain= 1.00000                                        NY Accelerat.
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                                   to Low-Pass Filters 
System Input 17 to Subsystem  3, Input  1, Gain= 2.5                                            KL_phi
System Input 18 to Subsystem  3, Input  2, Gain= 2.73                                           KM_theta
System Input 19 to Subsystem  3, Input  3, Gain= 2.73                                           KN_psi
System Input 20 to Subsystem  3, Input  1, Gain= 2.2                                            KL_p
System Input 21 to Subsystem  3, Input  2, Gain= 2.3                                            KM_q
System Input 22 to Subsystem  3, Input  3, Gain= 2.3                                            KN_r
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                                   to Integrator-4
System Input 18 to Subsystem  4, Input  1, Gain= 1.0                                            Theta
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                                   to Integrator-5
System Input 19 to Subsystem  5, Input  1, Gain= 1.0                                            Psi
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                         Alfa Estim to Filters
Subsystem  1, Output  1 to Subsystem  3, Input  2, Gain= 0.25                                   KM_alfa
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                                         Beta Estim to Filters
Subsystem  2, Output  1 to Subsystem  3, Input  3, Gain= -0.25                                  KN_beta= - Km_alfa
..............................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  3                                                         Theta-int to Low-Pass
Subsystem  4, Output  1 to Subsystem  3, Input  2, Gain= 0.4                                    KM_thint
..............................................................................
SUBSYSTEM NO  5 GOES TO SUBSYSTEM NO  3                                                         Psi-int to to Low-Pass
Subsystem  5, Output  1 to Subsystem  3, Input  3, Gain= 0.4                                    KN_psint
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                                from Low-Pass Filters 
System Output  1 from Subsystem  3, Output  1, Gain= -1.0                                       DP_tvc
System Output  2 from Subsystem  3, Output  2, Gain= -1.0                                       DQ_tvc
System Output  3 from Subsystem  3, Output  3, Gain= -1.0                                       DR_tvc
..............................................................................
Definitions of Inputs  =  24
Engine Pitch Deflect Comd delta y_1 (rad)  
Engine Pitch Deflect Comd delta y_2 (rad)   
Engine Pitch Deflect Comd delta y_3 (rad)   
Engine Pitch Deflect Comd delta y_4 (rad)   
Engine Pitch Deflect Comd delta y_5 (rad)   
Engine Pitch Deflect Comd delta y_6 (rad)   
Engine Pitch Deflect Comd delta y_7 (rad)   
Engine Pitch Deflect Comd delta y_8 (rad)   
Engine Yaw Deflect Commnd delta z_1 (rad)   
Engine Yaw Deflect Commnd delta z_2 (rad)   
Engine Yaw Deflect Commnd delta z_3 (rad)   
Engine Yaw Deflect Commnd delta z_4 (rad)   
Engine Yaw Deflect Commnd delta z_5 (rad)   
Engine Yaw Deflect Commnd delta z_6 (rad)   
Engine Yaw Deflect Commnd delta z_7 (rad)   
Engine Yaw Deflect Commnd delta z_8 (rad)  
Roll  Attitude Error (rad)                  
Pitch Attitude Error (rad)
Yaw   Attitude Error (rad)
Roll  Rate (rad/sec)                        
Pitch Rate (rad/sec)
Yaw   Rate (rad/sec)
Normal  Acceleration NZ (ft/sec^2)         
Lateral Acceleration NY (ft/sec^2)         
 
Definitions of Outputs =   3
Roll  FCS Demand DP_tvc
Pitch FCS Demand DQ_tvc
Yaw   FCS Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Closed-Loop System
! Combines the Plant Model with the Flight Control System in
! Closed-Loop form
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=30 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
System Input  1 to Subsystem  1, Input 17, Gain= -1.0                                                      Roll Command
System Input  2 to Subsystem  1, Input 18, Gain= -1.0                                                      Ptch Command
System Input  3 to Subsystem  1, Input 19, Gain= -1.0                                                      Yaw  Command
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehi
System Input  4 to Subsystem  2, Input 17, Gain=  1.0                                                      Wind Gust
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    FCS
Via Matrix +TVC                                                                     
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                                    FCS to Vehi
Via Matrix +TVC                                                                                            DY(8), DZ(8)                                                                     
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                           Vehicle Outputs
Via Matrix +I32                                                                     
..............................................................................
Definitions of Inputs  =   4
Roll  Attitude Command (rad)  
Pitch Attitude Command (rad)  
Yaw   Attitude Command (rad)  
Wind-Gust Velocity (feet/sec)

Definitions of Outputs =  32
Roll Attitude  (phi)    (radians)                                                         
Roll Rate      (p-body) (rad/sec)                                                         
Pitch Attitude (thet)   (radians)                                                         
Pitch Rate     (q-body) (rad/sec)                                                         
Yaw  Attitude  (psi)    (radians)                                                         
Yaw  Rate      (r-body) (rad/sec)                                                         
Angle of attack, alfa,   (radian)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Rate-Gyro #  1, Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro #  3, Yaw Rate   (Body) (rad/sec)                                                  
Accelerom #  1, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Engine #1 Pitch Deflection dy-1 (rad)        
Engine #2 Pitch Deflection dy-2 (rad)        
Engine #3 Pitch Deflection dy-3 (rad)        
Engine #4 Pitch Deflection dy-4 (rad)        
Engine #5 Pitch Deflection dy-5 (rad)        
Engine #6 Pitch Deflection dy-6 (rad)        
Engine #7 Pitch Deflection dy-7 (rad)        
Engine #8 Pitch Deflection dy-8 (rad)        
Engine #1 Yaw Deflection dz-1 (rad)        
Engine #2 Yaw Deflection dz-2 (rad)        
Engine #3 Yaw Deflection dz-3 (rad)        
Engine #4 Yaw Deflection dz-4 (rad)        
Engine #5 Yaw Deflection dz-5 (rad)        
Engine #6 Yaw Deflection dz-6 (rad)        
Engine #7 Yaw Deflection dz-7 (rad)        
Engine #8 Yaw Deflection dz-8 (rad)        
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Open-Loop System
! Combines the Plant Model with the Flight Control System in
! Open-Loop config
!
Titles of Systems to be Combined
Title 1 Flight Control System                                                   
Title 2 Plant Model at T=30 sec, Vehicle/ Actuators             
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To FCS
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                                              To Vehicle
Via Matrix +TVC                                                                                            DP, DQ, DR
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  2, Output  1 to Subsystem  1, Input 17, Gain= 1.0                                               Roll Attit f/b
Subsystem  2, Output  3 to Subsystem  1, Input 18, Gain= 1.0                                               Ptch Attit f/b
Subsystem  2, Output  5 to Subsystem  1, Input 19, Gain= 1.0                                               Yaw  Attit f/b
Subsystem  2, Output 12 to Subsystem  1, Input 20, Gain= 1.0                                               Roll Rate f/b
Subsystem  2, Output 13 to Subsystem  1, Input 21, Gain= 1.0                                               Ptch Rate f/b
Subsystem  2, Output 14 to Subsystem  1, Input 22, Gain= 1.0                                               Yaw  Rate f/b
Subsystem  2, Output 16 to Subsystem  1, Input 23, Gain= 1.0                                               Nz f/b
Subsystem  2, Output 15 to Subsystem  1, Input 24, Gain= 1.0                                               Ny f/b
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           Vehicle Outputs
Via Matrix +I03                                                                     
..............................................................................
Definitions of Inputs  =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc

Definitions of Outputs =   3
Roll  Control Demand DP_tvc
Pitch Control Demand DQ_tvc
Yaw   Control Demand DR_tvc
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Roll Loop Opened, Others Closed
! Roll Loop Opened for Roll Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                                       Roll Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  1, Gain= -1.0                                                  DP_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw Closed
..............................................................................
Definitions of Inputs  =   1
Roll Control Demand DP_tvc 

Definitions of Outputs =   1
Roll Control Demand DP_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Pitch Loop Opened, Others Closed
! Pitch Loop Opened for Pitch Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  2, Gain= 1.0                                                       Pitch Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  2, Gain= -1.0                                                  DQ_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll Closed
Subsystem  1, Output  3 to Subsystem  1, Input  3, Gain= 1.0                                               Yaw  Closed
..............................................................................
Definitions of Inputs  =   1
Pitch Control Demand DQ_tvc 

Definitions of Outputs =   1
Pitch Control Demand DQ_tvc 
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Yaw Loop Opened, Others Closed
! Roll Loop Opened for Yaw Stability Analysis.
! The other two loops are closed
!
Titles of Systems to be Combined
Title 1 Open-Loop System
SYSTEM INPUTS TO SUBSYSTEM  1                                                                              To Open-Loop System
System Input  1 to Subsystem  1, Input  3, Gain= 1.0                                                       Yaw Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                           from Open-Loop System
System Output  1 from Subsystem  1, Output  3, Gain= -1.0                                                  DR_tvc
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  1                                                                    Vehi to FCS
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 1.0                                               Roll  Closed
Subsystem  1, Output  2 to Subsystem  1, Input  2, Gain= 1.0                                               Pitch Closed
..............................................................................
Definitions of Inputs  =   1
Yaw Control Demand DR_tvc 

Definitions of Outputs =   1
Yaw Control Demand DR_tvc 
--------------------------------------------------------------------------------------------------------------------------------
                            CONVERT TO MATLAB DATA
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=30.0 sec 
Matrix TVC
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=30.0 sec 
System
flex_vehicle.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
----------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Flight Control System
System
fcs.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model at T=30 sec, Vehicle/ Actuators
System
plant.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Closed-Loop System
System
closed_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Open-Loop System
System
open_loop.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Roll Loop Opened, Others Closed
System
roll_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Loop Opened, Others Closed
System
pitch_open.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Yaw Loop Opened, Others Closed
System
yaw_open.m
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 80% Full 
First Stage Flex Modes at 80% Full Tanks
! Flex Modes, First Stage 80% Full Tanks from File: Stg1_80%.Mod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.619       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.13258D-01   0.12513D+00  -0.53673D-02  -0.20143D-05  -0.23065D-03  -0.54455D-02
S1 Engine No:2 +Y-Z               1152     0.59556D-02   0.12512D+00  -0.53663D-02   0.30440D-06  -0.22986D-03  -0.54571D-02
S1 Engine No:3 -Y-Z               1153    -0.48387D-02   0.12512D+00  -0.53681D-02   0.10664D-06  -0.23730D-03  -0.54574D-02
S1 Engine No:4 -Y-Z               1154    -0.12796D-01   0.12513D+00  -0.53670D-02  -0.18635D-05  -0.23766D-03  -0.54457D-02
S1 Engine No:5 -Y+Z               1155    -0.13259D-01   0.12513D+00  -0.53670D-02   0.20796D-05  -0.23072D-03  -0.54456D-02
S1 Engine No:6 -Y+Z               1156    -0.59564D-02   0.12512D+00  -0.53663D-02  -0.55699D-06  -0.22973D-03  -0.54572D-02
S1 Engine No:7 +Y+Z               1157     0.48381D-02   0.12512D+00  -0.53684D-02  -0.23922D-06  -0.23741D-03  -0.54574D-02
S1 Engine No:8 +Y+Z               1158     0.12795D-01   0.12513D+00  -0.53674D-02   0.21198D-05  -0.23748D-03  -0.54458D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02  -0.89210D-08   0.18146D-03   0.42308D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02  -0.89210D-08   0.18146D-03   0.42308D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02  -0.89210D-08   0.18146D-03   0.42308D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.31317D-06  -0.51921D-01   0.22274D-02  -0.85915D-08   0.53065D-04   0.12370D-02
Fuel Slosh Mass Locat.             600    -0.36785D-06   0.34664D-02  -0.14842D-03  -0.79295D-08  -0.19051D-03  -0.44412D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.28256D-04   0.12584D+00  -0.53977D-02   0.19920D-04  -0.25744D-03  -0.60020D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.620       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.48392D-02   0.53689D-02   0.12515D+00   0.54482D-07   0.54582D-02  -0.23742D-03
S1 Engine No:2 +Y-Z               1152    -0.12797D-01   0.53679D-02   0.12515D+00  -0.18631D-05   0.54468D-02  -0.23768D-03
S1 Engine No:3 -Y-Z               1153    -0.13261D-01   0.53679D-02   0.12515D+00   0.18037D-05   0.54464D-02  -0.23058D-03
S1 Engine No:4 -Y-Z               1154    -0.59569D-02   0.53672D-02   0.12515D+00  -0.41291D-06   0.54580D-02  -0.22978D-03
S1 Engine No:5 -Y+Z               1155     0.48392D-02   0.53693D-02   0.12515D+00  -0.30450D-06   0.54583D-02  -0.23746D-03
S1 Engine No:6 -Y+Z               1156     0.12797D-01   0.53684D-02   0.12515D+00   0.19357D-05   0.54468D-02  -0.23755D-03
S1 Engine No:7 +Y+Z               1157     0.13260D-01   0.53683D-02   0.12515D+00  -0.20302D-05   0.54464D-02  -0.23062D-03
S1 Engine No:8 +Y+Z               1158     0.59568D-02   0.53673D-02   0.12515D+00   0.25764D-06   0.54580D-02  -0.22979D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01  -0.84506D-07  -0.42307D-02   0.18150D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01  -0.84506D-07  -0.42307D-02   0.18150D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01  -0.84506D-07  -0.42307D-02   0.18150D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.11036D-07  -0.22273D-02  -0.51931D-01  -0.81790D-07  -0.12371D-02   0.53058D-04
Fuel Slosh Mass Locat.             600    -0.13529D-07   0.14901D-03   0.34675D-02  -0.75378D-07   0.44420D-02  -0.19054D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.12561D-05   0.53986D-02   0.12586D+00  -0.11217D-04   0.60026D-02  -0.25758D-03

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.748       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.23665D-02  -0.13244D-01  -0.33593D-06   0.10274D-05  -0.12947D-05   0.92765D-03
S1 Engine No:2 +Y-Z               1152    -0.10628D-02  -0.13243D-01  -0.87455D-06  -0.11597D-06  -0.13440D-05   0.93284D-03
S1 Engine No:3 -Y-Z               1153     0.78336D-03  -0.13243D-01   0.24048D-07  -0.95887D-07   0.15907D-05   0.93272D-03
S1 Engine No:4 -Y-Z               1154     0.20871D-02  -0.13244D-01  -0.50723D-06   0.95627D-06   0.14929D-05   0.92737D-03
S1 Engine No:5 -Y+Z               1155     0.20873D-02  -0.13244D-01  -0.50036D-06  -0.10700D-05  -0.13632D-05   0.92746D-03
S1 Engine No:6 -Y+Z               1156     0.78343D-03  -0.13243D-01  -0.89622D-06   0.24930D-06  -0.16724D-05   0.93278D-03
S1 Engine No:7 +Y+Z               1157    -0.10628D-02  -0.13243D-01   0.17719D-06   0.16380D-06   0.13997D-05   0.93284D-03
S1 Engine No:8 +Y+Z               1158    -0.23665D-02  -0.13244D-01  -0.33847D-06  -0.11033D-05   0.12778D-05   0.92765D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07   0.63282D-08   0.29664D-07   0.15280D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07   0.63282D-08   0.29664D-07   0.15280D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07   0.63282D-08   0.29664D-07   0.15280D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10431D-03  -0.35067D-02   0.33198D-06   0.52496D-08  -0.84475D-08  -0.63271D-03
Fuel Slosh Mass Locat.             600    -0.13297D-03   0.62693D-02  -0.40145D-06   0.30072D-08  -0.18526D-07   0.47131D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.12280D-03  -0.13678D-01   0.25841D-06  -0.12256D-04   0.42815D-06   0.12616D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    52.312       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.16229D-02   0.11939D-05   0.21658D-01   0.88276D-07   0.16396D-02  -0.29766D-05
S1 Engine No:2 +Y-Z               1152    -0.39143D-02   0.55613D-07   0.21660D-01  -0.20924D-05   0.16288D-02  -0.28050D-05
S1 Engine No:3 -Y-Z               1153    -0.39143D-02   0.14353D-06   0.21660D-01   0.18980D-05   0.16289D-02   0.29034D-05
S1 Engine No:4 -Y-Z               1154    -0.16226D-02  -0.58851D-06   0.21658D-01  -0.42467D-06   0.16396D-02   0.31531D-05
S1 Engine No:5 -Y+Z               1155     0.16230D-02   0.16903D-05   0.21658D-01  -0.49682D-06   0.16397D-02  -0.30187D-05
S1 Engine No:6 -Y+Z               1156     0.39144D-02   0.86621D-06   0.21660D-01   0.20921D-05   0.16288D-02  -0.26412D-05
S1 Engine No:7 +Y+Z               1157     0.39141D-02   0.90286D-06   0.21660D-01  -0.22679D-05   0.16288D-02   0.28526D-05
S1 Engine No:8 +Y+Z               1158     0.16226D-02  -0.34716D-06   0.21658D-01   0.11878D-06   0.16396D-02   0.31438D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02  -0.44897D-07   0.28300D-02   0.92958D-07
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02  -0.44897D-07   0.28300D-02   0.92958D-07
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02  -0.44897D-07   0.28300D-02   0.92958D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10010D-08  -0.10480D-05   0.11604D-01  -0.91564D-07  -0.11748D-02  -0.31422D-07
Fuel Slosh Mass Locat.             600     0.10638D-08   0.12139D-05  -0.11825D-01  -0.12979D-06   0.68406D-03  -0.38282D-07

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.25058D-07  -0.15577D-05   0.22614D-01  -0.17068D-04   0.23615D-02   0.13500D-05

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.533       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.15026D-01   0.74080D-01  -0.11455D-03  -0.11019D-04   0.16126D-05  -0.62581D-02
S1 Engine No:2 +Y-Z               1152     0.62243D-02   0.74069D-01  -0.10874D-03   0.13255D-05   0.28322D-05  -0.63103D-02
S1 Engine No:3 -Y-Z               1153    -0.62697D-02   0.74069D-01  -0.11831D-03   0.10331D-05  -0.23201D-04  -0.63103D-02
S1 Engine No:4 -Y-Z               1154    -0.15100D-01   0.74080D-01  -0.11260D-03  -0.10179D-04  -0.23297D-04  -0.62580D-02
S1 Engine No:5 -Y+Z               1155    -0.15123D-01   0.74078D-01  -0.11298D-03   0.11573D-04   0.10407D-05  -0.62588D-02
S1 Engine No:6 -Y+Z               1156    -0.63201D-02   0.74068D-01  -0.10870D-03  -0.27106D-05   0.34925D-05  -0.63109D-02
S1 Engine No:7 +Y+Z               1157     0.61747D-02   0.74068D-01  -0.12006D-03  -0.17353D-05  -0.24083D-04  -0.63104D-02
S1 Engine No:8 +Y+Z               1158     0.15005D-01   0.74079D-01  -0.11434D-03   0.11969D-04  -0.22205D-04  -0.62581D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04  -0.11150D-06  -0.14507D-04  -0.92590D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04  -0.11150D-06  -0.14507D-04  -0.92590D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04  -0.11150D-06  -0.14507D-04  -0.92590D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.21348D-04   0.62319D-01  -0.10364D-03  -0.77726D-07   0.60550D-05   0.38798D-02
Fuel Slosh Mass Locat.             600    -0.41409D-04  -0.48579D-01   0.84193D-04  -0.14483D-07  -0.23880D-05  -0.17399D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.28329D-03   0.79622D-01  -0.14202D-03   0.16208D-03  -0.30145D-04  -0.10458D-01

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    64.060       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.60911D-02  -0.13416D-03  -0.72253D-01  -0.10353D-05  -0.61776D-02   0.23611D-04
S1 Engine No:2 +Y-Z               1152     0.14738D-01  -0.12930D-03  -0.72263D-01   0.97955D-05  -0.61268D-02   0.22992D-04
S1 Engine No:3 -Y-Z               1153     0.14758D-01  -0.12991D-03  -0.72262D-01  -0.10076D-04  -0.61270D-02  -0.21770D-05
S1 Engine No:4 -Y-Z               1154     0.61405D-02  -0.12540D-03  -0.72253D-01   0.15336D-05  -0.61777D-02  -0.33863D-05
S1 Engine No:5 -Y+Z               1155    -0.60915D-02  -0.13546D-03  -0.72253D-01   0.18630D-05  -0.61781D-02   0.23827D-04
S1 Engine No:6 -Y+Z               1156    -0.14738D-01  -0.13044D-03  -0.72263D-01  -0.11067D-04  -0.61267D-02   0.22148D-04
S1 Engine No:7 +Y+Z               1157    -0.14757D-01  -0.13078D-03  -0.72263D-01   0.10706D-04  -0.61266D-02  -0.19174D-05
S1 Engine No:8 +Y+Z               1158    -0.61403D-02  -0.12538D-03  -0.72253D-01  -0.12302D-05  -0.61777D-02  -0.33364D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01   0.33461D-07  -0.89310D-02   0.15844D-04
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01   0.33461D-07  -0.89310D-02   0.15844D-04
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01   0.33461D-07  -0.89310D-02   0.15844D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.40553D-07  -0.10255D-03  -0.61282D-01   0.58580D-07   0.37453D-02  -0.66671D-05
Fuel Slosh Mass Locat.             600     0.71988D-07   0.76136D-04   0.47599D-01   0.68060D-07  -0.16715D-02   0.33014D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.27941D-07  -0.12000D-03  -0.77542D-01   0.95856D-04  -0.10143D-01   0.45066D-05

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    83.739       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.20675D-01   0.80825D-01  -0.63987D-02  -0.20641D-04  -0.64777D-03  -0.83021D-02
S1 Engine No:2 +Y-Z               1152     0.98880D-02   0.80805D-01  -0.63895D-02   0.43430D-05  -0.63937D-03  -0.83903D-02
S1 Engine No:3 -Y-Z               1153    -0.67306D-02   0.80805D-01  -0.64079D-02   0.83176D-06  -0.67518D-03  -0.83928D-02
S1 Engine No:4 -Y-Z               1154    -0.19374D-01   0.80826D-01  -0.63960D-02  -0.18560D-04  -0.68260D-03  -0.83045D-02
S1 Engine No:5 -Y+Z               1155    -0.20693D-01   0.80818D-01  -0.63973D-02   0.22649D-04  -0.64889D-03  -0.83034D-02
S1 Engine No:6 -Y+Z               1156    -0.99028D-02   0.80800D-01  -0.63902D-02  -0.65941D-05  -0.63773D-03  -0.83915D-02
S1 Engine No:7 +Y+Z               1157     0.67176D-02   0.80800D-01  -0.64109D-02  -0.13948D-05  -0.67658D-03  -0.83930D-02
S1 Engine No:8 +Y+Z               1158     0.19361D-01   0.80823D-01  -0.63978D-02   0.22973D-04  -0.68027D-03  -0.83051D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02  -0.59341D-06   0.17509D-03   0.22062D-02
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02  -0.59341D-06   0.17509D-03   0.22062D-02
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02  -0.59341D-06   0.17509D-03   0.22062D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.14653D-04   0.55039D-01  -0.43575D-02  -0.28572D-06  -0.15536D-04  -0.19456D-03
Fuel Slosh Mass Locat.             600     0.28037D-05  -0.64356D-01   0.50966D-02   0.16242D-06  -0.46898D-04  -0.59296D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.63997D-03   0.94954D-01  -0.75213D-02   0.45410D-03  -0.14897D-02  -0.18793D-01

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    83.794       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.67229D-02  -0.64554D-02  -0.81240D-01  -0.55265D-06  -0.83952D-02   0.67829D-03
S1 Engine No:2 +Y-Z               1152     0.19374D-01  -0.64446D-02  -0.81260D-01   0.18319D-04  -0.83082D-02   0.68450D-03
S1 Engine No:3 -Y-Z               1153     0.20694D-01  -0.64464D-02  -0.81257D-01  -0.19632D-04  -0.83056D-02   0.64794D-03
S1 Engine No:4 -Y-Z               1154     0.99018D-02  -0.64390D-02  -0.81239D-01   0.43130D-05  -0.83926D-02   0.63919D-03
S1 Engine No:5 -Y+Z               1155    -0.67227D-02  -0.64573D-02  -0.81238D-01   0.17572D-05  -0.83960D-02   0.67882D-03
S1 Engine No:6 -Y+Z               1156    -0.19374D-01  -0.64457D-02  -0.81260D-01  -0.21074D-04  -0.83081D-02   0.68286D-03
S1 Engine No:7 +Y+Z               1157    -0.20692D-01  -0.64470D-02  -0.81259D-01   0.20632D-04  -0.83047D-02   0.64849D-03
S1 Engine No:8 +Y+Z               1158    -0.99008D-02  -0.64384D-02  -0.81240D-01  -0.43390D-05  -0.83929D-02   0.63935D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01   0.52826D-07   0.21869D-02  -0.17312D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01   0.52826D-07   0.21869D-02  -0.17312D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01   0.52826D-07   0.21869D-02  -0.17312D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10834D-05  -0.43839D-02  -0.55246D-01  -0.15546D-07  -0.18202D-03   0.14316D-04
Fuel Slosh Mass Locat.             600    -0.22168D-06   0.51049D-02   0.64349D-01  -0.70020D-07  -0.61504D-03   0.48847D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.46665D-04  -0.74626D-02  -0.94075D-01   0.21221D-03  -0.17886D-01   0.14190D-02

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    103.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.43586D-06   0.20870D-01   0.50396D-01   0.21113D-01   0.92629D-07   0.16076D-06
S1 Engine No:2 +Y-Z               1152    -0.83106D-07   0.50390D-01   0.20877D-01   0.21113D-01  -0.39119D-06  -0.38326D-06
S1 Engine No:3 -Y-Z               1153    -0.10568D-05   0.50390D-01  -0.20871D-01   0.21113D-01   0.68750D-06  -0.37496D-06
S1 Engine No:4 -Y-Z               1154    -0.12156D-05   0.20870D-01  -0.50391D-01   0.21113D-01   0.15965D-06   0.10635D-06
S1 Engine No:5 -Y+Z               1155    -0.11386D-05  -0.20877D-01  -0.50391D-01   0.21113D-01   0.14696D-06  -0.95303D-06
S1 Engine No:6 -Y+Z               1156    -0.23407D-06  -0.50397D-01  -0.20871D-01   0.21113D-01   0.61501D-06  -0.40530D-06
S1 Engine No:7 +Y+Z               1157     0.33944D-06  -0.50397D-01   0.20877D-01   0.21113D-01  -0.42132D-06  -0.41069D-06
S1 Engine No:8 +Y+Z               1158     0.88265D-06  -0.20877D-01   0.50396D-01   0.21113D-01   0.12622D-06  -0.89605D-06

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05  -0.26316D-01  -0.27137D-06   0.36439D-06
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05  -0.26316D-01  -0.27137D-06   0.36439D-06
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05  -0.26316D-01  -0.27137D-06   0.36439D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10157D-06  -0.54081D-05   0.17104D-05  -0.41376D-02   0.22060D-07  -0.25321D-06
Fuel Slosh Mass Locat.             600    -0.11053D-06  -0.10503D-05  -0.14086D-05   0.14879D-01   0.91278D-07   0.41300D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.33261D-05   0.29211D-04  -0.10326D-04   0.24215D-01  -0.12518D-04  -0.26204D-04

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    110.84       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.41279D-05  -0.17748D-01  -0.42834D-01  -0.17948D-01   0.10843D-05   0.10763D-05
S1 Engine No:2 +Y-Z               1152    -0.35301D-05  -0.42843D-01  -0.17739D-01  -0.17948D-01   0.15458D-05   0.16134D-05
S1 Engine No:3 -Y-Z               1153    -0.12620D-06  -0.42843D-01   0.17750D-01  -0.17948D-01   0.48631D-06   0.16086D-05
S1 Engine No:4 -Y-Z               1154     0.33932D-05  -0.17748D-01   0.42845D-01  -0.17948D-01   0.10148D-05   0.11355D-05
S1 Engine No:5 -Y+Z               1155     0.56425D-05   0.17741D-01   0.42845D-01  -0.17948D-01   0.10340D-05   0.21700D-05
S1 Engine No:6 -Y+Z               1156     0.46658D-05   0.42836D-01   0.17750D-01  -0.17948D-01   0.56671D-06   0.16369D-05
S1 Engine No:7 +Y+Z               1157     0.16540D-05   0.42836D-01  -0.17739D-01  -0.17948D-01   0.15750D-05   0.16410D-05
S1 Engine No:8 +Y+Z               1158    -0.22425D-05   0.17741D-01  -0.42834D-01  -0.17948D-01   0.10487D-05   0.21107D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05   0.24637D-01  -0.11477D-05  -0.10331D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05   0.24637D-01  -0.11477D-05  -0.10331D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05   0.24637D-01  -0.11477D-05  -0.10331D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.20762D-06   0.90737D-05  -0.35238D-05   0.51185D-02   0.41953D-06   0.57892D-06
Fuel Slosh Mass Locat.             600     0.36648D-06   0.67058D-05  -0.52876D-05  -0.11889D-01  -0.29728D-06  -0.75047D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.48199D-05  -0.56174D-04   0.27636D-04  -0.21046D-01   0.20078D-04   0.41704D-04

MODE# 11/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    119.57       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.30881D-01  -0.70371D-01   0.54653D-02   0.43348D-04   0.87484D-03   0.11004D-01
S1 Engine No:2 +Y-Z               1152    -0.16646D-01  -0.70322D-01   0.54388D-02  -0.39142D-06   0.87984D-03   0.11092D-01
S1 Engine No:3 -Y-Z               1153     0.52834D-02  -0.70321D-01   0.54551D-02   0.53129D-05   0.87420D-03   0.11071D-01
S1 Engine No:4 -Y-Z               1154     0.21923D-01  -0.70370D-01   0.54230D-02   0.39523D-04   0.87322D-03   0.10957D-01
S1 Engine No:5 -Y+Z               1155     0.23637D-01  -0.70369D-01   0.54273D-02  -0.33653D-04   0.85715D-03   0.10961D-01
S1 Engine No:6 -Y+Z               1156     0.93955D-02  -0.70344D-01   0.54243D-02   0.19838D-04   0.83111D-03   0.11075D-01
S1 Engine No:7 +Y+Z               1157    -0.12538D-01  -0.70345D-01   0.54740D-02   0.97403D-05   0.83165D-03   0.11092D-01
S1 Engine No:8 +Y+Z               1158    -0.29177D-01  -0.70380D-01   0.54599D-02  -0.34040D-04   0.84833D-03   0.11004D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02  -0.14540D-04  -0.68678D-03  -0.89563D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02  -0.14540D-04  -0.68678D-03  -0.89563D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02  -0.14540D-04  -0.68678D-03  -0.89563D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.64135D-03   0.35430D-01  -0.27704D-02  -0.71146D-07   0.27610D-03   0.35744D-02
Fuel Slosh Mass Locat.             600    -0.26107D-02   0.53398D-01  -0.41428D-02   0.70331D-05  -0.20719D-03  -0.26393D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.14585D-02  -0.17375D+00   0.13655D-01  -0.37384D-02   0.66887D-02   0.84523D-01

MODE# 12/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    121.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.95002D-02   0.64831D-02   0.82532D-01   0.27884D-05   0.11869D-01  -0.92302D-03
S1 Engine No:2 +Y-Z               1152    -0.27329D-01   0.64615D-02   0.82574D-01  -0.37148D-04   0.11734D-01  -0.93463D-03
S1 Engine No:3 -Y-Z               1153    -0.29160D-01   0.64679D-02   0.82565D-01   0.43085D-04   0.11734D-01  -0.91436D-03
S1 Engine No:4 -Y-Z               1154    -0.13905D-01   0.64500D-02   0.82522D-01  -0.81238D-05   0.11869D-01  -0.90192D-03
S1 Engine No:5 -Y+Z               1155     0.95967D-02   0.64849D-02   0.82522D-01  -0.28381D-05   0.11872D-01  -0.92362D-03
S1 Engine No:6 -Y+Z               1156     0.27424D-01   0.64576D-02   0.82571D-01   0.46612D-04   0.11735D-01  -0.93037D-03
S1 Engine No:7 +Y+Z               1157     0.29251D-01   0.64627D-02   0.82574D-01  -0.42634D-04   0.11732D-01  -0.91592D-03
S1 Engine No:8 +Y+Z               1158     0.13999D-01   0.64459D-02   0.82532D-01   0.10839D-04   0.11870D-01  -0.90293D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01  -0.38952D-05  -0.10856D-01   0.86044D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01  -0.38952D-05  -0.10856D-01   0.86044D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01  -0.38952D-05  -0.10856D-01   0.86044D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.29252D-05  -0.27447D-02  -0.35432D-01  -0.78805D-07   0.40054D-02  -0.31496D-03
Fuel Slosh Mass Locat.             600     0.38925D-04  -0.46112D-02  -0.59008D-01   0.17934D-05  -0.24536D-02   0.18871D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.21726D-03   0.11645D-01   0.15182D+00  -0.13140D-02   0.61559D-01  -0.46500D-02

MODE# 13/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    129.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.73567D-02  -0.74641D-03  -0.11531D-03  -0.13979D-05   0.21398D-03   0.26957D-02
S1 Engine No:2 +Y-Z               1152    -0.39399D-02  -0.74536D-03  -0.11443D-03  -0.33782D-06   0.22338D-03   0.26478D-02
S1 Engine No:3 -Y-Z               1153     0.12626D-02  -0.74489D-03  -0.11548D-03  -0.69220D-06   0.17023D-03   0.26380D-02
S1 Engine No:4 -Y-Z               1154     0.51982D-02  -0.74549D-03  -0.11477D-03  -0.15688D-05   0.16494D-03   0.26783D-02
S1 Engine No:5 -Y+Z               1155     0.55655D-02  -0.74323D-03  -0.11243D-03  -0.54268D-06   0.20842D-03   0.26828D-02
S1 Engine No:6 -Y+Z               1156     0.21481D-02  -0.74061D-03  -0.11336D-03  -0.54538D-06   0.20995D-03   0.26422D-02
S1 Engine No:7 +Y+Z               1157    -0.30548D-02  -0.74074D-03  -0.11678D-03  -0.74544D-06   0.15738D-03   0.26438D-02
S1 Engine No:8 +Y+Z               1158    -0.69903D-02  -0.74399D-03  -0.11813D-03  -0.62344D-06   0.15869D-03   0.26915D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03  -0.11998D-04   0.10148D-02   0.12671D-01
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03  -0.11998D-04   0.10148D-02   0.12671D-01
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03  -0.11998D-04   0.10148D-02   0.12671D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10194D-03   0.35951D-02  -0.22636D-03   0.20634D-05  -0.18379D-03  -0.22573D-02
Fuel Slosh Mass Locat.             600    -0.75106D-03   0.13279D-02   0.30263D-05   0.40673D-05  -0.11814D-03  -0.15446D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.53783D-02  -0.12048D+00   0.93525D-02  -0.45305D-02   0.68314D-02   0.86759D-01

MODE# 14/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.81       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.64579D-02  -0.38849D-02  -0.47179D-01   0.24889D-06  -0.81751D-02   0.65048D-03
S1 Engine No:2 +Y-Z               1152     0.18768D-01  -0.38672D-02  -0.47212D-01   0.26690D-04  -0.81090D-02   0.65782D-03
S1 Engine No:3 -Y-Z               1153     0.20084D-01  -0.38729D-02  -0.47209D-01  -0.26838D-04  -0.81109D-02   0.67220D-03
