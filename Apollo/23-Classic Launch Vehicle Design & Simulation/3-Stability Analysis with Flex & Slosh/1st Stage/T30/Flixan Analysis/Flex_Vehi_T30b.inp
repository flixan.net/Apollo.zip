S1 Engine No:4 -Y-Z               1154     0.96234D-02  -0.38638D-02  -0.47182D-01   0.76565D-05  -0.81769D-02   0.66642D-03
S1 Engine No:5 -Y+Z               1155    -0.65521D-02  -0.38903D-02  -0.47182D-01   0.39298D-05  -0.81769D-02   0.65065D-03
S1 Engine No:6 -Y+Z               1156    -0.18861D-01  -0.38743D-02  -0.47214D-01  -0.29384D-04  -0.81094D-02   0.65460D-03
S1 Engine No:7 +Y+Z               1157    -0.20174D-01  -0.38791D-02  -0.47212D-01   0.30672D-04  -0.81101D-02   0.67344D-03
S1 Engine No:8 +Y+Z               1158    -0.97160D-02  -0.38649D-02  -0.47180D-01  -0.54468D-05  -0.81775D-02   0.66743D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02   0.36978D-05  -0.11583D-01   0.90797D-03
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02   0.36978D-05  -0.11583D-01   0.90797D-03
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02   0.36978D-05  -0.11583D-01   0.90797D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.44020D-05   0.11093D-02   0.13491D-01  -0.86293D-06   0.13499D-02  -0.10312D-03
Fuel Slosh Mass Locat.             600    -0.40636D-04   0.23158D-02   0.28204D-01  -0.10304D-05   0.23420D-02  -0.18821D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.34781D-03  -0.11274D-01  -0.14116D+00   0.18592D-02  -0.74897D-01   0.59287D-02

MODE# 15/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    142.33       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.30942D-01   0.11540D+00  -0.94226D-02  -0.11325D-03  -0.96806D-03  -0.12289D-01
S1 Engine No:2 +Y-Z               1152     0.14765D-01   0.11528D+00  -0.93497D-02  -0.24642D-05  -0.93324D-03  -0.12650D-01
S1 Engine No:3 -Y-Z               1153    -0.10363D-01   0.11528D+00  -0.93863D-02  -0.18193D-04  -0.10571D-02  -0.12661D-01
S1 Engine No:4 -Y-Z               1154    -0.29401D-01   0.11540D+00  -0.93016D-02  -0.10344D-03  -0.10917D-02  -0.12301D-01
S1 Engine No:5 -Y+Z               1155    -0.31457D-01   0.11541D+00  -0.93064D-02   0.76622D-04  -0.97517D-03  -0.12299D-01
S1 Engine No:6 -Y+Z               1156    -0.15267D-01   0.11536D+00  -0.93072D-02  -0.54025D-04  -0.93013D-03  -0.12659D-01
S1 Engine No:7 +Y+Z               1157     0.98701D-02   0.11536D+00  -0.94462D-02  -0.30428D-04  -0.10673D-02  -0.12661D-01
S1 Engine No:8 +Y+Z               1158     0.28908D-01   0.11543D+00  -0.94196D-02   0.77917D-04  -0.10827D-02  -0.12300D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03  -0.20816D-04  -0.28420D-03  -0.34730D-02
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03  -0.20816D-04  -0.28420D-03  -0.34730D-02
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03  -0.20816D-04  -0.28420D-03  -0.34730D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.14553D-03  -0.16754D-01   0.13592D-02   0.84942D-05  -0.63793D-04  -0.78979D-03
Fuel Slosh Mass Locat.             600    -0.46750D-03  -0.62292D-01   0.50579D-02  -0.13105D-05   0.12482D-03   0.15362D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.94485D-02  -0.58543D-01   0.47370D-02  -0.70517D-02   0.87227D-02   0.10763D+00

MODE# 16/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    150.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.70918D-02   0.76658D-02   0.93809D-01   0.44857D-04   0.88584D-02  -0.78120D-03
S1 Engine No:2 +Y-Z               1152    -0.20454D-01   0.77090D-02   0.93791D-01   0.61823D-05   0.85284D-02  -0.81208D-03
S1 Engine No:3 -Y-Z               1153    -0.21885D-01   0.77213D-02   0.93680D-01   0.10043D-03   0.85152D-02  -0.62557D-03
S1 Engine No:4 -Y-Z               1154    -0.10525D-01   0.76307D-02   0.93558D-01   0.47357D-04   0.88448D-02  -0.59828D-03
S1 Engine No:5 -Y+Z               1155     0.70910D-02   0.75716D-02   0.93557D-01   0.52609D-04   0.88622D-02  -0.78336D-03
S1 Engine No:6 -Y+Z               1156     0.20451D-01   0.74680D-02   0.93689D-01   0.10876D-03   0.85273D-02  -0.80502D-03
S1 Engine No:7 +Y+Z               1157     0.21876D-01   0.74779D-02   0.93793D-01  -0.22096D-05   0.85116D-02  -0.62808D-03
S1 Engine No:8 +Y+Z               1158     0.10521D-01   0.75265D-02   0.93809D-01   0.56280D-04   0.88460D-02  -0.59879D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02   0.28793D-04   0.13432D-02  -0.10845D-03
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02   0.28793D-04   0.13432D-02  -0.10845D-03
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02   0.28793D-04   0.13432D-02  -0.10845D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.25861D-04  -0.76807D-03  -0.94726D-02  -0.16451D-04   0.81640D-03  -0.66226D-04
Fuel Slosh Mass Locat.             600    -0.45985D-04  -0.40421D-02  -0.49865D-01   0.13780D-04  -0.53044D-03   0.42984D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.12160D-02  -0.13381D-01  -0.16465D+00   0.56905D-02  -0.17102D+00   0.13910D-01

MODE# 17/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    156.58       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.30985D-04  -0.35088D-01  -0.84344D-01  -0.35402D-01   0.14022D-04   0.45636D-05
S1 Engine No:2 +Y-Z               1152    -0.41101D-04  -0.84590D-01  -0.34843D-01  -0.35402D-01   0.15197D-04   0.71388D-05
S1 Engine No:3 -Y-Z               1153    -0.25669D-04  -0.84590D-01   0.35165D-01  -0.35402D-01   0.11183D-04   0.74321D-05
S1 Engine No:4 -Y-Z               1154     0.31384D-05  -0.35088D-01   0.84666D-01  -0.35402D-01   0.13980D-04   0.51199D-05
S1 Engine No:5 -Y+Z               1155     0.31766D-04   0.34919D-01   0.84666D-01  -0.35402D-01   0.13829D-04   0.89179D-05
S1 Engine No:6 -Y+Z               1156     0.40302D-04   0.84421D-01   0.35164D-01  -0.35402D-01   0.11237D-04   0.72169D-05
S1 Engine No:7 +Y+Z               1157     0.26471D-04   0.84421D-01  -0.34842D-01  -0.35402D-01   0.15516D-04   0.75607D-05
S1 Engine No:8 +Y+Z               1158    -0.38858D-05   0.34919D-01  -0.84344D-01  -0.35402D-01   0.14078D-04   0.90576D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05  -0.14730D-01   0.15917D-05   0.83011D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05  -0.14730D-01   0.15917D-05   0.83011D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05  -0.14730D-01   0.15917D-05   0.83011D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.19486D-06   0.66683D-05  -0.12675D-04   0.10061D-01   0.15002D-05   0.78836D-06
Fuel Slosh Mass Locat.             600     0.23184D-06   0.45333D-04  -0.86259D-04  -0.12209D-01  -0.28480D-06  -0.15686D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.76199D-05   0.19447D-03  -0.38299D-03  -0.50320D-01  -0.34885D-03  -0.17183D-03

MODE# 18/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    205.68       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11551D-01  -0.34900D-01   0.22499D-02   0.61446D-04   0.30191D-03   0.46385D-02
S1 Engine No:2 +Y-Z               1152    -0.53047D-02  -0.34839D-01   0.22202D-02  -0.14972D-04   0.28723D-03   0.48362D-02
S1 Engine No:3 -Y-Z               1153     0.43048D-02  -0.34839D-01   0.22785D-02  -0.59234D-05   0.30311D-03   0.48404D-02
S1 Engine No:4 -Y-Z               1154     0.11416D-01  -0.34901D-01   0.22429D-02   0.53866D-04   0.32554D-03   0.46471D-02
S1 Engine No:5 -Y+Z               1155     0.12050D-01  -0.34875D-01   0.22470D-02  -0.69896D-04   0.31019D-03   0.46522D-02
S1 Engine No:6 -Y+Z               1156     0.57947D-02  -0.34817D-01   0.22233D-02   0.22555D-04   0.29062D-03   0.48451D-02
S1 Engine No:7 +Y+Z               1157    -0.38232D-02  -0.34817D-01   0.22897D-02   0.72832D-05   0.31612D-03   0.48383D-02
S1 Engine No:8 +Y+Z               1158    -0.10934D-01  -0.34889D-01   0.22474D-02  -0.71292D-04   0.32066D-03   0.46398D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03  -0.23882D-06   0.80590D-04   0.12637D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03  -0.23882D-06   0.80590D-04   0.12637D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03  -0.23882D-06   0.80590D-04   0.12637D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10099D-03   0.81455D-01  -0.52643D-02   0.41693D-06  -0.11744D-03  -0.18023D-02
Fuel Slosh Mass Locat.             600     0.97909D-04  -0.19971D-01   0.12994D-02  -0.16399D-05  -0.28753D-03  -0.44389D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.88532D-03  -0.19997D-01   0.13940D-02   0.97991D-03  -0.21138D-03  -0.44134D-02

MODE# 19/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    247.37       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.93223D-02  -0.20592D-01   0.47641D-04   0.58147D-04   0.42534D-04   0.36828D-02
S1 Engine No:2 +Y-Z               1152    -0.41463D-02  -0.20529D-01   0.13510D-04  -0.10785D-04   0.51668D-04   0.37964D-02
S1 Engine No:3 -Y-Z               1153     0.33554D-02  -0.20529D-01   0.66192D-04  -0.89287D-05  -0.16276D-04   0.37856D-02
S1 Engine No:4 -Y-Z               1154     0.85567D-02  -0.20588D-01   0.33201D-04   0.51352D-04  -0.95080D-05   0.36604D-02
S1 Engine No:5 -Y+Z               1155     0.85880D-02  -0.20567D-01   0.37777D-04  -0.64913D-04   0.38291D-04   0.36678D-02
S1 Engine No:6 -Y+Z               1156     0.34014D-02  -0.20510D-01   0.12848D-04   0.21665D-04   0.25756D-04   0.37930D-02
S1 Engine No:7 +Y+Z               1157    -0.41101D-02  -0.20512D-01   0.80025D-04   0.13123D-04  -0.32550D-04   0.37972D-02
S1 Engine No:8 +Y+Z               1158    -0.93102D-02  -0.20579D-01   0.43566D-04  -0.67774D-04  -0.28388D-04   0.36821D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03  -0.91094D-07  -0.39367D-05  -0.19432D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03  -0.91094D-07  -0.39367D-05  -0.19432D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03  -0.91094D-07  -0.39367D-05  -0.19432D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.19049D-03  -0.84372D-01   0.18001D-03   0.24353D-06  -0.16950D-04  -0.82878D-02
Fuel Slosh Mass Locat.             600     0.99431D-04  -0.23789D-01   0.59010D-04  -0.15221D-05  -0.44298D-05  -0.20124D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.12528D-02  -0.12773D-01   0.24846D-03   0.10355D-02   0.15486D-03  -0.68654D-03

MODE# 20/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    247.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.39325D-02  -0.62305D-04  -0.21597D-01  -0.90637D-05  -0.39893D-02  -0.25013D-04
S1 Engine No:2 +Y-Z               1152     0.94135D-02  -0.32208D-04  -0.21655D-01   0.53765D-04  -0.38717D-02  -0.18378D-04
S1 Engine No:3 -Y-Z               1153     0.94292D-02  -0.39168D-04  -0.21651D-01  -0.55814D-04  -0.38724D-02   0.33210D-04
S1 Engine No:4 -Y-Z               1154     0.39644D-02  -0.12980D-04  -0.21595D-01   0.14532D-04  -0.39910D-02   0.35885D-04
S1 Engine No:5 -Y+Z               1155    -0.39358D-02  -0.75236D-04  -0.21595D-01   0.15848D-04  -0.39929D-02  -0.24125D-04
S1 Engine No:6 -Y+Z               1156    -0.94128D-02  -0.44040D-04  -0.21657D-01  -0.63332D-04  -0.38701D-02  -0.25446D-04
S1 Engine No:7 +Y+Z               1157    -0.94209D-02  -0.49023D-04  -0.21662D-01   0.60818D-04  -0.38692D-02   0.34517D-04
S1 Engine No:8 +Y+Z               1158    -0.39619D-02  -0.13552D-04  -0.21597D-01  -0.92753D-05  -0.39899D-02   0.36660D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01   0.44041D-06   0.19758D-02  -0.37998D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01   0.44041D-06   0.19758D-02  -0.37998D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01   0.44041D-06   0.19758D-02  -0.37998D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.94579D-06  -0.16101D-03  -0.88772D-01  -0.22685D-06   0.86598D-02  -0.16480D-04
Fuel Slosh Mass Locat.             600     0.11673D-05  -0.36600D-04  -0.25016D-01   0.13381D-05   0.21049D-02  -0.36674D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.20996D-04   0.21671D-03  -0.10407D-01  -0.89908D-03   0.28375D-02  -0.17244D-03

MODE# 21/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    280.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.26688D-03  -0.93916D-03  -0.35470D-03  -0.34480D-03   0.76075D-04   0.89082D-04
S1 Engine No:2 +Y-Z               1152    -0.24026D-03  -0.14238D-02   0.13172D-03  -0.34981D-03   0.70931D-04   0.95750D-04
S1 Engine No:3 -Y-Z               1153    -0.49683D-04  -0.14237D-02   0.82151D-03  -0.34622D-03   0.69245D-04   0.96168D-04
S1 Engine No:4 -Y-Z               1154     0.18363D-03  -0.94081D-03   0.13046D-02  -0.34596D-03   0.75215D-04   0.90538D-04
S1 Engine No:5 -Y+Z               1155     0.33544D-03  -0.25022D-03   0.13047D-02  -0.35087D-03   0.77443D-04   0.91782D-04
S1 Engine No:6 -Y+Z               1156     0.30817D-03   0.23720D-03   0.81942D-03  -0.34460D-03   0.72858D-04   0.97284D-04
S1 Engine No:7 +Y+Z               1157     0.11695D-03   0.23724D-03   0.13506D-03  -0.34890D-03   0.71773D-04   0.95215D-04
S1 Engine No:8 +Y+Z               1158    -0.11615D-03  -0.25276D-03  -0.35465D-03  -0.35015D-03   0.75782D-04   0.88351D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04  -0.59743D-04   0.12203D-06   0.23099D-06
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04  -0.59743D-04   0.12203D-06   0.23099D-06
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04  -0.59743D-04   0.12203D-06   0.23099D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.14285D-04  -0.24937D-03   0.18963D-03   0.20920D-03   0.41213D-05   0.42894D-05
Fuel Slosh Mass Locat.             600     0.28396D-04  -0.37058D-03   0.29283D-03  -0.17011D-02  -0.19108D-04  -0.23557D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.63137D-03  -0.72091D-02   0.52875D-02   0.11759D+01   0.22507D-02   0.35880D-02

MODE# 22/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    297.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.16023D-01   0.44146D-01  -0.29296D-03  -0.22250D-03  -0.83616D-04  -0.62983D-02
S1 Engine No:2 +Y-Z               1152     0.68622D-02   0.43920D-01  -0.15730D-03   0.43336D-04  -0.92789D-04  -0.68612D-02
S1 Engine No:3 -Y-Z               1153    -0.67825D-02   0.43921D-01  -0.36572D-03   0.35220D-04   0.31906D-04  -0.68570D-02
S1 Engine No:4 -Y-Z               1154    -0.16056D-01   0.44134D-01  -0.23648D-03  -0.19470D-03  -0.19351D-04  -0.62946D-02
S1 Engine No:5 -Y+Z               1155    -0.16190D-01   0.44057D-01  -0.23605D-03   0.24274D-03  -0.10575D-03  -0.63226D-02
S1 Engine No:6 -Y+Z               1156    -0.69895D-02   0.43864D-01  -0.14776D-03  -0.96546D-04  -0.76516D-04  -0.68890D-02
S1 Engine No:7 +Y+Z               1157     0.67011D-02   0.43868D-01  -0.43624D-03  -0.60383D-04   0.17278D-04  -0.68677D-02
S1 Engine No:8 +Y+Z               1158     0.15965D-01   0.44105D-01  -0.29877D-03   0.25404D-03   0.19085D-04  -0.62945D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03  -0.14216D-06   0.23135D-06  -0.23610D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03  -0.14216D-06   0.23135D-06  -0.23610D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03  -0.14216D-06   0.23135D-06  -0.23610D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.76113D-04   0.11273D+00  -0.57520D-03   0.55714D-06   0.45138D-05   0.11292D-02
Fuel Slosh Mass Locat.             600    -0.97258D-04   0.62587D-01  -0.33330D-03  -0.50468D-05   0.16902D-04   0.30323D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.20078D-02   0.30287D-01  -0.53481D-03   0.34663D-02  -0.24695D-03  -0.40771D-03

MODE# 23/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    297.77       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.66800D-02   0.27043D-03   0.43307D-01   0.42583D-04   0.67907D-02   0.16162D-04
S1 Engine No:2 +Y-Z               1152    -0.15891D-01   0.16781D-03   0.43493D-01  -0.18626D-03   0.62666D-02  -0.69966D-05
S1 Engine No:3 -Y-Z               1153    -0.15964D-01   0.17314D-03   0.43471D-01   0.20123D-03   0.62693D-02  -0.64078D-04
S1 Engine No:4 -Y-Z               1154    -0.68341D-02   0.76786D-04   0.43285D-01  -0.58450D-04   0.67988D-02  -0.70770D-04
S1 Engine No:5 -Y+Z               1155     0.66975D-02   0.31414D-03   0.43285D-01  -0.58822D-04   0.68029D-02   0.15203D-04
S1 Engine No:6 -Y+Z               1156     0.15891D-01   0.19682D-03   0.43496D-01   0.22678D-03   0.62604D-02   0.18682D-04
S1 Engine No:7 +Y+Z               1157     0.15936D-01   0.19545D-03   0.43519D-01  -0.21077D-03   0.62575D-02  -0.66899D-04
S1 Engine No:8 +Y+Z               1158     0.68281D-02   0.72448D-04   0.43307D-01   0.41300D-04   0.67918D-02  -0.74603D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01   0.36689D-06  -0.43573D-04  -0.19265D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01   0.36689D-06  -0.43573D-04  -0.19265D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01   0.36689D-06  -0.43573D-04  -0.19265D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.12665D-05   0.59203D-03   0.11097D+00  -0.48958D-06  -0.92173D-03   0.61895D-05
Fuel Slosh Mass Locat.             600    -0.23031D-05   0.31984D-03   0.62589D-01   0.38386D-05  -0.29948D-02   0.14518D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.51669D-04  -0.24871D-03   0.24776D-01  -0.26644D-02  -0.30948D-02   0.26149D-03

MODE# 24/ 39, Frequency (rad/sec), Damping (zeta), Generalized Mass=    374.18       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.15123D-01  -0.28717D-01   0.71421D-04   0.40798D-03   0.34786D-03   0.62288D-02
S1 Engine No:2 +Y-Z               1152    -0.65504D-02  -0.28283D-01  -0.22868D-03  -0.74707D-04   0.41711D-03   0.68042D-02
S1 Engine No:3 -Y-Z               1153     0.68069D-02  -0.28283D-01   0.14989D-03  -0.79584D-04  -0.43408D-03   0.68041D-02
S1 Engine No:4 -Y-Z               1154     0.15438D-01  -0.28646D-01  -0.93482D-04   0.32176D-03  -0.27422D-03   0.62375D-02
S1 Engine No:5 -Y+Z               1155     0.15613D-01  -0.28419D-01  -0.11908D-03  -0.48365D-03   0.43019D-03   0.63049D-02
S1 Engine No:6 -Y+Z               1156     0.69192D-02  -0.28081D-01  -0.27324D-03   0.26996D-03   0.38923D-03   0.69284D-02
S1 Engine No:7 +Y+Z               1157    -0.66420D-02  -0.28094D-01   0.42006D-03   0.16088D-03  -0.42487D-03   0.68572D-02
S1 Engine No:8 +Y+Z               1158    -0.15197D-01  -0.28572D-01   0.11474D-03  -0.52774D-03  -0.40363D-03   0.62095D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05   0.10418D-07  -0.10509D-05  -0.46667D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05   0.10418D-07  -0.10509D-05  -0.46667D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05   0.10418D-07  -0.10509D-05  -0.46667D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.26045D-03   0.59487D-01  -0.20864D-04  -0.43292D-07   0.23513D-05   0.89288D-02
Fuel Slosh Mass Locat.             600    -0.90711D-05  -0.39811D-01   0.33666D-04   0.59892D-06   0.12245D-05  -0.30988D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.24567D-02  -0.19110D-01   0.26452D-03  -0.37093D-03   0.18401D-03   0.34273D-02

MODE# 25/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    376.70       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.74670D-02  -0.17988D-03  -0.32013D-01  -0.13628D-03  -0.76286D-02  -0.43055D-03
S1 Engine No:2 +Y-Z               1152     0.17185D-01   0.37045D-04  -0.32377D-01   0.38028D-03  -0.70135D-02  -0.33756D-03
S1 Engine No:3 -Y-Z               1153     0.17236D-01   0.55869D-04  -0.32289D-01  -0.44838D-03  -0.70163D-02   0.37878D-03
S1 Engine No:4 -Y-Z               1154     0.75084D-02   0.25870D-03  -0.31914D-01   0.20303D-03  -0.76724D-02   0.42308D-03
S1 Engine No:5 -Y+Z               1155    -0.75746D-02  -0.38187D-03  -0.31919D-01   0.17027D-03  -0.76649D-02  -0.45418D-03
S1 Engine No:6 -Y+Z               1156    -0.17198D-01  -0.81239D-04  -0.32401D-01  -0.53252D-03  -0.69836D-02  -0.43396D-03
S1 Engine No:7 +Y+Z               1157    -0.17124D-01  -0.41188D-04  -0.32496D-01   0.45917D-03  -0.69712D-02   0.36920D-03
S1 Engine No:8 +Y+Z               1158    -0.75008D-02   0.28317D-03  -0.32019D-01  -0.89236D-04  -0.76091D-02   0.44960D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01   0.90382D-06   0.46688D-02  -0.14819D-05
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01   0.90382D-06   0.46688D-02  -0.14819D-05
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01   0.90382D-06   0.46688D-02  -0.14819D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.18222D-05   0.10076D-04   0.62268D-01  -0.31256D-06  -0.89356D-02   0.23831D-05
Fuel Slosh Mass Locat.             600     0.29051D-05   0.17934D-04  -0.42622D-01  -0.45812D-06   0.19500D-03  -0.16086D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.55314D-04   0.29316D-03  -0.17387D-01   0.31478D-03  -0.93569D-03  -0.20863D-03

MODE# 26/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    393.85       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.83988D-01   0.15500D+00  -0.54367D-02  -0.31538D-02  -0.37298D-02  -0.33286D-01
S1 Engine No:2 +Y-Z               1152     0.40151D-01   0.15144D+00  -0.27556D-02   0.27486D-03  -0.44357D-02  -0.37678D-01
S1 Engine No:3 -Y-Z               1153    -0.33483D-01   0.15140D+00  -0.51615D-02   0.45941D-03   0.22150D-02  -0.37571D-01
S1 Engine No:4 -Y-Z               1154    -0.81041D-01   0.15390D+00  -0.33593D-02  -0.20344D-02   0.62539D-03  -0.33125D-01
S1 Engine No:5 -Y+Z               1155    -0.85166D-01   0.15119D+00  -0.30644D-02   0.40462D-02  -0.45926D-02  -0.33888D-01
S1 Engine No:6 -Y+Z               1156    -0.39791D-01   0.14888D+00  -0.22582D-02  -0.28453D-02  -0.38484D-02  -0.39241D-01
S1 Engine No:7 +Y+Z               1157     0.36588D-01   0.14905D+00  -0.87795D-02  -0.13842D-02   0.26639D-02  -0.38420D-01
S1 Engine No:8 +Y+Z               1158     0.82900D-01   0.15323D+00  -0.59531D-02   0.46666D-02   0.23990D-02  -0.32936D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03  -0.49817D-07  -0.45012D-04  -0.13232D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03  -0.49817D-07  -0.45012D-04  -0.13232D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03  -0.49817D-07  -0.45012D-04  -0.13232D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.11500D-02  -0.34223D-01   0.98256D-03   0.19266D-06  -0.81871D-05  -0.53525D-03
Fuel Slosh Mass Locat.             600    -0.13441D-02   0.13763D+00  -0.41942D-02  -0.27566D-05  -0.14899D-03  -0.48254D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.19664D-01   0.10324D+00  -0.38774D-02   0.16399D-02  -0.11888D-02  -0.22160D-01

MODE# 27/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    394.32       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.34074D-01   0.56894D-02   0.15253D+00   0.91759D-03   0.37735D-01   0.17680D-02
S1 Engine No:2 +Y-Z               1152    -0.82199D-01   0.43066D-02   0.15475D+00  -0.23160D-02   0.33588D-01   0.91548D-03
S1 Engine No:3 -Y-Z               1153    -0.85086D-01   0.40964D-02   0.15376D+00   0.30739D-02   0.33827D-01  -0.37642D-02
S1 Engine No:4 -Y-Z               1154    -0.39782D-01   0.30377D-02   0.15155D+00  -0.17999D-02   0.38376D-01  -0.38407D-02
S1 Engine No:5 -Y+Z               1155     0.35254D-01   0.78041D-02   0.15163D+00  -0.10754D-02   0.38005D-01   0.21095D-02
S1 Engine No:6 -Y+Z               1156     0.82294D-01   0.54318D-02   0.15514D+00   0.38070D-02   0.33254D-01   0.18450D-02
S1 Engine No:7 +Y+Z               1157     0.83972D-01   0.50170D-02   0.15591D+00  -0.31674D-02   0.33359D-01  -0.36458D-02
S1 Engine No:8 +Y+Z               1158     0.39817D-01   0.26432D-02   0.15260D+00   0.52870D-03   0.37642D-01  -0.41700D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01   0.21596D-06   0.14441D-02  -0.39974D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01   0.21596D-06   0.14441D-02  -0.39974D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01   0.21596D-06   0.14441D-02  -0.39974D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.54144D-04  -0.10631D-02  -0.32642D-01  -0.22158D-06   0.34259D-03  -0.18326D-04
Fuel Slosh Mass Locat.             600    -0.64189D-04   0.42127D-02   0.13682D+00   0.18113D-05   0.47904D-02  -0.14564D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.93893D-03   0.17936D-02   0.82105D-01  -0.11725D-02   0.68821D-02   0.30714D-03

MODE# 28/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    436.90       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.14080D-01   0.39006D-01   0.34313D-02  -0.23153D-01  -0.17656D-01   0.70799D-02
S1 Engine No:2 +Y-Z               1152     0.23630D-01   0.21992D-01   0.14696D-01   0.11754D-01  -0.17047D-01  -0.27203D-01
S1 Engine No:3 -Y-Z               1153    -0.25597D-01   0.22554D-01  -0.17480D-01   0.68430D-02   0.20832D-01  -0.23813D-01
S1 Engine No:4 -Y-Z               1154    -0.10949D-01   0.42708D-01  -0.19782D-02  -0.21289D-01   0.13871D-01   0.11157D-01
S1 Engine No:5 -Y+Z               1155    -0.14381D-01   0.39650D-01   0.29601D-02   0.22922D-01  -0.17482D-01   0.70854D-02
S1 Engine No:6 -Y+Z               1156    -0.24108D-01   0.22508D-01   0.14481D-01  -0.11261D-01  -0.17113D-01  -0.26869D-01
S1 Engine No:7 +Y+Z               1157     0.24466D-01   0.23033D-01  -0.16783D-01  -0.66233D-02   0.20610D-01  -0.23557D-01
S1 Engine No:8 +Y+Z               1158     0.10091D-01   0.42864D-01  -0.14785D-02   0.20813D-01   0.13532D-01   0.11122D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03  -0.59761D-08   0.30432D-04   0.34518D-02
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03  -0.59761D-08   0.30432D-04   0.34518D-02
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03  -0.59761D-08   0.30432D-04   0.34518D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.57611D-03   0.16526D+00  -0.14409D-02   0.27889D-07   0.11662D-03   0.13387D-01
Fuel Slosh Mass Locat.             600     0.14910D-03  -0.10299D-01   0.93614D-04  -0.44405D-06  -0.29789D-04  -0.34236D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.63058D-02   0.21391D-01  -0.44089D-03   0.23555D-03  -0.23279D-03  -0.65040D-02

MODE# 29/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    436.94       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.21985D-01  -0.13945D-01  -0.24459D-01  -0.77792D-02  -0.22895D-01  -0.16037D-01
S1 Engine No:2 +Y-Z               1152     0.13554D-01  -0.25064D-02  -0.40303D-01   0.18857D-01   0.64321D-02  -0.13326D-01
S1 Engine No:3 -Y-Z               1153     0.13528D-01   0.16682D-02  -0.40530D-01  -0.18676D-01   0.64900D-02   0.13312D-01
S1 Engine No:4 -Y-Z               1154     0.22225D-01   0.13183D-01  -0.24680D-01   0.75565D-02  -0.22728D-01   0.16226D-01
S1 Engine No:5 -Y+Z               1155    -0.21744D-01  -0.13562D-01  -0.24651D-01   0.77783D-02  -0.22856D-01  -0.15936D-01
S1 Engine No:6 -Y+Z               1156    -0.13508D-01  -0.22979D-02  -0.40281D-01  -0.18635D-01   0.63792D-02  -0.13190D-01
S1 Engine No:7 +Y+Z               1157    -0.13724D-01   0.18590D-02  -0.40159D-01   0.18757D-01   0.64344D-02   0.13398D-01
S1 Engine No:8 +Y+Z               1158    -0.22244D-01   0.13165D-01  -0.24450D-01  -0.78508D-02  -0.22926D-01   0.16165D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01   0.43321D-07   0.34852D-02  -0.30475D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01   0.43321D-07   0.34852D-02  -0.30475D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01   0.43321D-07   0.34852D-02  -0.30475D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.14620D-04  -0.14579D-02  -0.16487D+00  -0.21581D-07   0.13355D-01  -0.11819D-03
Fuel Slosh Mass Locat.             600    -0.44297D-05   0.84644D-04   0.99971D-02  -0.28225D-06  -0.34202D-02   0.30289D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.14385D-03   0.11458D-03  -0.16121D-01   0.16868D-03  -0.26928D-02  -0.15598D-03

MODE# 30/ 67, Frequency (rad/sec), Damping (zeta), Generalized Mass=    589.84       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.78876D-01   0.45701D-01   0.97462D-02   0.11910D-02   0.39337D-02  -0.47983D-01
S1 Engine No:2 +Y-Z               1152     0.16052D-01   0.46230D-01   0.90735D-02  -0.18390D-03   0.51721D-02  -0.37748D-01
S1 Engine No:3 -Y-Z               1153    -0.55504D-01   0.46479D-01   0.10856D-01  -0.83947D-03   0.16966D-01  -0.40022D-01
S1 Engine No:4 -Y-Z               1154    -0.95516D-01   0.46293D-01   0.10496D-01   0.14785D-02   0.13439D-01  -0.50927D-01
S1 Engine No:5 -Y+Z               1155    -0.79560D-01   0.45991D-01   0.93752D-02  -0.18540D-02   0.41116D-02  -0.49036D-01
S1 Engine No:6 -Y+Z               1156    -0.16002D-01   0.47093D-01   0.83771D-02   0.10275D-02   0.60510D-02  -0.36587D-01
S1 Engine No:7 +Y+Z               1157     0.53629D-01   0.47242D-01   0.12088D-01   0.84428D-03   0.15275D-01  -0.39316D-01
S1 Engine No:8 +Y+Z               1158     0.94952D-01   0.46094D-01   0.10819D-01  -0.17718D-02   0.13553D-01  -0.51788D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02  -0.19320D-07   0.17915D-03  -0.80506D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02  -0.19320D-07   0.17915D-03  -0.80506D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02  -0.19320D-07   0.17915D-03  -0.80506D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10419D-03  -0.82528D-02  -0.18371D-02   0.54634D-08  -0.37120D-03   0.16674D-02
Fuel Slosh Mass Locat.             600     0.22948D-03  -0.13347D+00  -0.29713D-01   0.10786D-05  -0.60282D-04   0.27182D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.17937D-01  -0.95227D-01  -0.16830D-01  -0.10981D-03  -0.23026D-02   0.23076D-01

MODE# 31/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    590.09       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.55288D-01   0.11369D-01  -0.46981D-01   0.12190D-02  -0.39710D-01  -0.16964D-01
S1 Engine No:2 +Y-Z               1152     0.95312D-01   0.11014D-01  -0.46732D-01  -0.15818D-02  -0.51041D-01  -0.13433D-01
S1 Engine No:3 -Y-Z               1153     0.79248D-01   0.99007D-02  -0.46469D-01   0.16050D-02  -0.48638D-01  -0.40432D-02
S1 Engine No:4 -Y-Z               1154     0.16032D-01   0.92737D-02  -0.47154D-01  -0.85685D-03  -0.37303D-01  -0.53665D-02
S1 Engine No:5 -Y+Z               1155    -0.54979D-01   0.12041D-01  -0.47304D-01  -0.73858D-03  -0.40038D-01  -0.16544D-01
S1 Engine No:6 -Y+Z               1156    -0.95326D-01   0.11393D-01  -0.46850D-01   0.14910D-02  -0.50927D-01  -0.13508D-01
S1 Engine No:7 +Y+Z               1157    -0.79938D-01   0.10385D-01  -0.45818D-01  -0.78650D-03  -0.48766D-01  -0.32188D-02
S1 Engine No:8 +Y+Z               1158    -0.16308D-01   0.92833D-02  -0.46645D-01  -0.30954D-03  -0.38261D-01  -0.57283D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02   0.12202D-07  -0.80760D-03  -0.17898D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02   0.12202D-07  -0.80760D-03  -0.17898D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02   0.12202D-07  -0.80760D-03  -0.17898D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.22656D-04  -0.18446D-02   0.83262D-02  -0.34108D-07   0.16697D-02   0.36988D-03
Fuel Slosh Mass Locat.             600     0.49824D-04  -0.29665D-01   0.13391D+00   0.11870D-06   0.26196D-03   0.58230D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.39692D-02  -0.22805D-01   0.83450D-01  -0.19790D-03   0.15712D-01   0.62786D-02
----------------------------------------------------------------------------------------------------------------------------
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
