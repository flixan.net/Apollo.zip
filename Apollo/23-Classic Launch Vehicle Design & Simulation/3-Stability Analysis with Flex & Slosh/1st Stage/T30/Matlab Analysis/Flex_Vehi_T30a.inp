BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Stage-1 Launch Vehicle Control Analysis at T=30 sec
! This batch set creates dynamic models for Control Analysis at T=30 sec
! Includes Slosh, Flexibility and Tail-Wags-Dog
!
Flight Vehicle   : Launch Vehicle First Stage Analysis Model, T=30.0 sec                                                       
Mixing Matrix    : Mixing Logic for First Stage Model, at T=30.0 sec 
Actuator Model   : Stage-1 Linear Actuator
!
To Matlab Format : Launch Vehicle First Stage Analysis Model, T=30.0 sec            
To Matlab Format : Mixing Logic for First Stage Model, at T=30.0 sec          
To Matlab Format : Stage-1 Linear Actuator             
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Launch Vehicle First Stage Analysis Model, T=30.0 sec                                       
! This is a Launch Vehicle Control Analysis Model at t=30 sec with 8 TVC Engines.
! The model includes two slosh modes for the LOX and LH2 tanks at 100% Propellant level.
! The LOX tank requires baffles and the damping coefficient was increased to 0.012 .
! The Flight Control Sensors include 3 Rate Gyros (p,q,r) and 2 Accelerometers (Ny,Nz).
! The model also includes 33 Structural Modes Selected between the TVC and the Nav Base
!                                                                               
Body Axes Output,Attitude=Rate Integral             

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   4618.67       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   33767.8      0.272623E+07  0.272527E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   57.4827       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.2630        296.760       88.9000       4003.85    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   13.0          45.07         0.0          -0.106    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   1.18000       0.0          -0.04         -0.0
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00          87.78         0.00000       0.0          -0.236        -0.0
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       90.0000                                                                 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   44.415        7.52000       7.52000    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   120.147       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.451       -0.00194        0.8315e-4     0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  -0.0         -0.0356         0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.0397      -0.0356         0.00000       0.00000       0.00000       0.00000      -0.1033e-3    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000      0.00000        0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.165        0.1113         0.00000      -0.00000       0.00000      -0.00166       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0         -0.1113         0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  8   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#1 +2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945       -1.0332     
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#2 +Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332       -2.4945 
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#3 -Y-2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332       -2.4945
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#4 -2Y-Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945       -1.0332 
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#5 -2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -2.4945        1.0332
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#6 -Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0         -1.0332        2.4945
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#7 +Y+2Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          1.0332        2.4945
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : TVC Eng#8 +2Y+Z  Gimbaling  
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   23120.0       23120.0
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       6.00000       6.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   5.43000       15.1200       1.22000
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   12.0          2.4945        1.0332 

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            97.438    0.000      0.000    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            97.438    0.000      0.000    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            97.438    0.000      0.000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      97.438    0.000      0.000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      97.438    0.000      0.000       

Number of Slosh Modes                                                                    :  2
LOX Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   441.7   3.11   3.11   0.015  0.015  67.68   0.0  0.0  
LH2 Mass  (slug), Frequency 1g (Wy,Wz) (rad/s), Damp (zeta-y-z), Locat.{Xsl,Ysl,Zsl} (ft):   151.9   3.11   3.11   0.01   0.01   37.94   0.0  0.0 

Number of Bending Modes                                                                  : 31
First Stage Flex Modes at 80% Full Tanks
---------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for First Stage Model, at T=30.0 sec 
! Thrust Vector Control Matrix at t=30 sec
! This multi-engine vehicle has 8 Gimbaling Engines.
TVC
Launch Vehicle First Stage Analysis Model, T=30.0 sec   
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL B   
Stage-1 Linear Actuator        
Symbol Parameter Description                    (Units)       Value 
C(s)   Order of Pade Delay (0,1,2)                ( - )       1, -0.001, 0.001
Ka     Gain of Amplifier ...................... (amps/volt)   28.0
Wsv    Bandwidth of the Linear Servo Actuator .  (rad/sec)    70.0    
Kact   Actuator Stiffness (Piston+Oil+Electric)   (lb/ft)     2.4e+6
Klod   Stiffness at Surface or Nozzle Connection  (lb/ft)     1.2e+9
Kbck   Stiffness at Vehicle Backup Structure ..   (lb/ft)     7.0e+7
R      Moment Arm between Actuator Rod & Gimbal   (feet)      0.667    
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)   15.12
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)   0.0
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)   550.0    
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for First Stage Model, at T=30.0 sec 
Matrix TVC
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Launch Vehicle First Stage Analysis Model, T=30.0 sec 
System
flex_vehicle.m
---------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Stage-1 Linear Actuator        
System
actuator.m
--------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 80% Full 
First Stage Flex Modes at 80% Full Tanks
! Flex Modes, First Stage 80% Full Tanks from File: Stg1_80%.Mod
! Sensors are at the Top of LOX Tank
! The Modes were selected between the TVC and the IMU Location

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.619       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.13258D-01   0.12513D+00  -0.53673D-02  -0.20143D-05  -0.23065D-03  -0.54455D-02
S1 Engine No:2 +Y-Z               1152     0.59556D-02   0.12512D+00  -0.53663D-02   0.30440D-06  -0.22986D-03  -0.54571D-02
S1 Engine No:3 -Y-Z               1153    -0.48387D-02   0.12512D+00  -0.53681D-02   0.10664D-06  -0.23730D-03  -0.54574D-02
S1 Engine No:4 -Y-Z               1154    -0.12796D-01   0.12513D+00  -0.53670D-02  -0.18635D-05  -0.23766D-03  -0.54457D-02
S1 Engine No:5 -Y+Z               1155    -0.13259D-01   0.12513D+00  -0.53670D-02   0.20796D-05  -0.23072D-03  -0.54456D-02
S1 Engine No:6 -Y+Z               1156    -0.59564D-02   0.12512D+00  -0.53663D-02  -0.55699D-06  -0.22973D-03  -0.54572D-02
S1 Engine No:7 +Y+Z               1157     0.48381D-02   0.12512D+00  -0.53684D-02  -0.23922D-06  -0.23741D-03  -0.54574D-02
S1 Engine No:8 +Y+Z               1158     0.12795D-01   0.12513D+00  -0.53674D-02   0.21198D-05  -0.23748D-03  -0.54458D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02  -0.89210D-08   0.18146D-03   0.42308D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02  -0.89210D-08   0.18146D-03   0.42308D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02  -0.89210D-08   0.18146D-03   0.42308D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.26997D-06   0.46172D-01  -0.19801D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.31317D-06  -0.51921D-01   0.22274D-02  -0.85915D-08   0.53065D-04   0.12370D-02
Fuel Slosh Mass Locat.             600    -0.36785D-06   0.34664D-02  -0.14842D-03  -0.79295D-08  -0.19051D-03  -0.44412D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.28256D-04   0.12584D+00  -0.53977D-02   0.19920D-04  -0.25744D-03  -0.60020D-02

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.620       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.48392D-02   0.53689D-02   0.12515D+00   0.54482D-07   0.54582D-02  -0.23742D-03
S1 Engine No:2 +Y-Z               1152    -0.12797D-01   0.53679D-02   0.12515D+00  -0.18631D-05   0.54468D-02  -0.23768D-03
S1 Engine No:3 -Y-Z               1153    -0.13261D-01   0.53679D-02   0.12515D+00   0.18037D-05   0.54464D-02  -0.23058D-03
S1 Engine No:4 -Y-Z               1154    -0.59569D-02   0.53672D-02   0.12515D+00  -0.41291D-06   0.54580D-02  -0.22978D-03
S1 Engine No:5 -Y+Z               1155     0.48392D-02   0.53693D-02   0.12515D+00  -0.30450D-06   0.54583D-02  -0.23746D-03
S1 Engine No:6 -Y+Z               1156     0.12797D-01   0.53684D-02   0.12515D+00   0.19357D-05   0.54468D-02  -0.23755D-03
S1 Engine No:7 +Y+Z               1157     0.13260D-01   0.53683D-02   0.12515D+00  -0.20302D-05   0.54464D-02  -0.23062D-03
S1 Engine No:8 +Y+Z               1158     0.59568D-02   0.53673D-02   0.12515D+00   0.25764D-06   0.54580D-02  -0.22979D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01  -0.84506D-07  -0.42307D-02   0.18150D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01  -0.84506D-07  -0.42307D-02   0.18150D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01  -0.84506D-07  -0.42307D-02   0.18150D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.91184D-08   0.19806D-02   0.46163D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.11036D-07  -0.22273D-02  -0.51931D-01  -0.81790D-07  -0.12371D-02   0.53058D-04
Fuel Slosh Mass Locat.             600    -0.13529D-07   0.14901D-03   0.34675D-02  -0.75378D-07   0.44420D-02  -0.19054D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.12561D-05   0.53986D-02   0.12586D+00  -0.11217D-04   0.60026D-02  -0.25758D-03

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.748       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.23665D-02  -0.13244D-01  -0.33593D-06   0.10274D-05  -0.12947D-05   0.92765D-03
S1 Engine No:2 +Y-Z               1152    -0.10628D-02  -0.13243D-01  -0.87455D-06  -0.11597D-06  -0.13440D-05   0.93284D-03
S1 Engine No:3 -Y-Z               1153     0.78336D-03  -0.13243D-01   0.24048D-07  -0.95887D-07   0.15907D-05   0.93272D-03
S1 Engine No:4 -Y-Z               1154     0.20871D-02  -0.13244D-01  -0.50723D-06   0.95627D-06   0.14929D-05   0.92737D-03
S1 Engine No:5 -Y+Z               1155     0.20873D-02  -0.13244D-01  -0.50036D-06  -0.10700D-05  -0.13632D-05   0.92746D-03
S1 Engine No:6 -Y+Z               1156     0.78343D-03  -0.13243D-01  -0.89622D-06   0.24930D-06  -0.16724D-05   0.93278D-03
S1 Engine No:7 +Y+Z               1157    -0.10628D-02  -0.13243D-01   0.17719D-06   0.16380D-06   0.13997D-05   0.93284D-03
S1 Engine No:8 +Y+Z               1158    -0.23665D-02  -0.13244D-01  -0.33847D-06  -0.11033D-05   0.12778D-05   0.92765D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07   0.63282D-08   0.29664D-07   0.15280D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07   0.63282D-08   0.29664D-07   0.15280D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07   0.63282D-08   0.29664D-07   0.15280D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.74126D-04   0.43627D-02  -0.61866D-07

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10431D-03  -0.35067D-02   0.33198D-06   0.52496D-08  -0.84475D-08  -0.63271D-03
Fuel Slosh Mass Locat.             600    -0.13297D-03   0.62693D-02  -0.40145D-06   0.30072D-08  -0.18526D-07   0.47131D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.12280D-03  -0.13678D-01   0.25841D-06  -0.12256D-04   0.42815D-06   0.12616D-02

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    52.312       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.16229D-02   0.11939D-05   0.21658D-01   0.88276D-07   0.16396D-02  -0.29766D-05
S1 Engine No:2 +Y-Z               1152    -0.39143D-02   0.55613D-07   0.21660D-01  -0.20924D-05   0.16288D-02  -0.28050D-05
S1 Engine No:3 -Y-Z               1153    -0.39143D-02   0.14353D-06   0.21660D-01   0.18980D-05   0.16289D-02   0.29034D-05
S1 Engine No:4 -Y-Z               1154    -0.16226D-02  -0.58851D-06   0.21658D-01  -0.42467D-06   0.16396D-02   0.31531D-05
S1 Engine No:5 -Y+Z               1155     0.16230D-02   0.16903D-05   0.21658D-01  -0.49682D-06   0.16397D-02  -0.30187D-05
S1 Engine No:6 -Y+Z               1156     0.39144D-02   0.86621D-06   0.21660D-01   0.20921D-05   0.16288D-02  -0.26412D-05
S1 Engine No:7 +Y+Z               1157     0.39141D-02   0.90286D-06   0.21660D-01  -0.22679D-05   0.16288D-02   0.28526D-05
S1 Engine No:8 +Y+Z               1158     0.16226D-02  -0.34716D-06   0.21658D-01   0.11878D-06   0.16396D-02   0.31438D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02  -0.44897D-07   0.28300D-02   0.92958D-07
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02  -0.44897D-07   0.28300D-02   0.92958D-07
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02  -0.44897D-07   0.28300D-02   0.92958D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02
Stage-2 Tank Top, IMU Locat.     40015     0.84077D-09   0.64974D-07  -0.32261D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10010D-08  -0.10480D-05   0.11604D-01  -0.91564D-07  -0.11748D-02  -0.31422D-07
Fuel Slosh Mass Locat.             600     0.10638D-08   0.12139D-05  -0.11825D-01  -0.12979D-06   0.68406D-03  -0.38282D-07

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.25058D-07  -0.15577D-05   0.22614D-01  -0.17068D-04   0.23615D-02   0.13500D-05

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.533       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.15026D-01   0.74080D-01  -0.11455D-03  -0.11019D-04   0.16126D-05  -0.62581D-02
S1 Engine No:2 +Y-Z               1152     0.62243D-02   0.74069D-01  -0.10874D-03   0.13255D-05   0.28322D-05  -0.63103D-02
S1 Engine No:3 -Y-Z               1153    -0.62697D-02   0.74069D-01  -0.11831D-03   0.10331D-05  -0.23201D-04  -0.63103D-02
S1 Engine No:4 -Y-Z               1154    -0.15100D-01   0.74080D-01  -0.11260D-03  -0.10179D-04  -0.23297D-04  -0.62580D-02
S1 Engine No:5 -Y+Z               1155    -0.15123D-01   0.74078D-01  -0.11298D-03   0.11573D-04   0.10407D-05  -0.62588D-02
S1 Engine No:6 -Y+Z               1156    -0.63201D-02   0.74068D-01  -0.10870D-03  -0.27106D-05   0.34925D-05  -0.63109D-02
S1 Engine No:7 +Y+Z               1157     0.61747D-02   0.74068D-01  -0.12006D-03  -0.17353D-05  -0.24083D-04  -0.63104D-02
S1 Engine No:8 +Y+Z               1158     0.15005D-01   0.74079D-01  -0.11434D-03   0.11969D-04  -0.22205D-04  -0.62581D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04  -0.11150D-06  -0.14507D-04  -0.92590D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04  -0.11150D-06  -0.14507D-04  -0.92590D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04  -0.11150D-06  -0.14507D-04  -0.92590D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.12631D-05   0.13017D-01  -0.20609D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.21348D-04   0.62319D-01  -0.10364D-03  -0.77726D-07   0.60550D-05   0.38798D-02
Fuel Slosh Mass Locat.             600    -0.41409D-04  -0.48579D-01   0.84193D-04  -0.14483D-07  -0.23880D-05  -0.17399D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.28329D-03   0.79622D-01  -0.14202D-03   0.16208D-03  -0.30145D-04  -0.10458D-01

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    64.060       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.60911D-02  -0.13416D-03  -0.72253D-01  -0.10353D-05  -0.61776D-02   0.23611D-04
S1 Engine No:2 +Y-Z               1152     0.14738D-01  -0.12930D-03  -0.72263D-01   0.97955D-05  -0.61268D-02   0.22992D-04
S1 Engine No:3 -Y-Z               1153     0.14758D-01  -0.12991D-03  -0.72262D-01  -0.10076D-04  -0.61270D-02  -0.21770D-05
S1 Engine No:4 -Y-Z               1154     0.61405D-02  -0.12540D-03  -0.72253D-01   0.15336D-05  -0.61777D-02  -0.33863D-05
S1 Engine No:5 -Y+Z               1155    -0.60915D-02  -0.13546D-03  -0.72253D-01   0.18630D-05  -0.61781D-02   0.23827D-04
S1 Engine No:6 -Y+Z               1156    -0.14738D-01  -0.13044D-03  -0.72263D-01  -0.11067D-04  -0.61267D-02   0.22148D-04
S1 Engine No:7 +Y+Z               1157    -0.14757D-01  -0.13078D-03  -0.72263D-01   0.10706D-04  -0.61266D-02  -0.19174D-05
S1 Engine No:8 +Y+Z               1158    -0.61403D-02  -0.12538D-03  -0.72253D-01  -0.12302D-05  -0.61777D-02  -0.33364D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01   0.33461D-07  -0.89310D-02   0.15844D-04
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01   0.33461D-07  -0.89310D-02   0.15844D-04
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01   0.33461D-07  -0.89310D-02   0.15844D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01
Stage-2 Tank Top, IMU Locat.     40015     0.76305D-08  -0.24077D-04  -0.13693D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.40553D-07  -0.10255D-03  -0.61282D-01   0.58580D-07   0.37453D-02  -0.66671D-05
Fuel Slosh Mass Locat.             600     0.71988D-07   0.76136D-04   0.47599D-01   0.68060D-07  -0.16715D-02   0.33014D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.27941D-07  -0.12000D-03  -0.77542D-01   0.95856D-04  -0.10143D-01   0.45066D-05

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    83.739       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.20675D-01   0.80825D-01  -0.63987D-02  -0.20641D-04  -0.64777D-03  -0.83021D-02
S1 Engine No:2 +Y-Z               1152     0.98880D-02   0.80805D-01  -0.63895D-02   0.43430D-05  -0.63937D-03  -0.83903D-02
S1 Engine No:3 -Y-Z               1153    -0.67306D-02   0.80805D-01  -0.64079D-02   0.83176D-06  -0.67518D-03  -0.83928D-02
S1 Engine No:4 -Y-Z               1154    -0.19374D-01   0.80826D-01  -0.63960D-02  -0.18560D-04  -0.68260D-03  -0.83045D-02
S1 Engine No:5 -Y+Z               1155    -0.20693D-01   0.80818D-01  -0.63973D-02   0.22649D-04  -0.64889D-03  -0.83034D-02
S1 Engine No:6 -Y+Z               1156    -0.99028D-02   0.80800D-01  -0.63902D-02  -0.65941D-05  -0.63773D-03  -0.83915D-02
S1 Engine No:7 +Y+Z               1157     0.67176D-02   0.80800D-01  -0.64109D-02  -0.13948D-05  -0.67658D-03  -0.83930D-02
S1 Engine No:8 +Y+Z               1158     0.19361D-01   0.80823D-01  -0.63978D-02   0.22973D-04  -0.68027D-03  -0.83051D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02  -0.59341D-06   0.17509D-03   0.22062D-02
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02  -0.59341D-06   0.17509D-03   0.22062D-02
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02  -0.59341D-06   0.17509D-03   0.22062D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02
Stage-2 Tank Top, IMU Locat.     40015     0.20675D-04  -0.35370D-01   0.28071D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.14653D-04   0.55039D-01  -0.43575D-02  -0.28572D-06  -0.15536D-04  -0.19456D-03
Fuel Slosh Mass Locat.             600     0.28037D-05  -0.64356D-01   0.50966D-02   0.16242D-06  -0.46898D-04  -0.59296D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.63997D-03   0.94954D-01  -0.75213D-02   0.45410D-03  -0.14897D-02  -0.18793D-01

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    83.794       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.67229D-02  -0.64554D-02  -0.81240D-01  -0.55265D-06  -0.83952D-02   0.67829D-03
S1 Engine No:2 +Y-Z               1152     0.19374D-01  -0.64446D-02  -0.81260D-01   0.18319D-04  -0.83082D-02   0.68450D-03
S1 Engine No:3 -Y-Z               1153     0.20694D-01  -0.64464D-02  -0.81257D-01  -0.19632D-04  -0.83056D-02   0.64794D-03
S1 Engine No:4 -Y-Z               1154     0.99018D-02  -0.64390D-02  -0.81239D-01   0.43130D-05  -0.83926D-02   0.63919D-03
S1 Engine No:5 -Y+Z               1155    -0.67227D-02  -0.64573D-02  -0.81238D-01   0.17572D-05  -0.83960D-02   0.67882D-03
S1 Engine No:6 -Y+Z               1156    -0.19374D-01  -0.64457D-02  -0.81260D-01  -0.21074D-04  -0.83081D-02   0.68286D-03
S1 Engine No:7 +Y+Z               1157    -0.20692D-01  -0.64470D-02  -0.81259D-01   0.20632D-04  -0.83047D-02   0.64849D-03
S1 Engine No:8 +Y+Z               1158    -0.99008D-02  -0.64384D-02  -0.81240D-01  -0.43390D-05  -0.83929D-02   0.63935D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01   0.52826D-07   0.21869D-02  -0.17312D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01   0.52826D-07   0.21869D-02  -0.17312D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01   0.52826D-07   0.21869D-02  -0.17312D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.15150D-05   0.28071D-02   0.35458D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10834D-05  -0.43839D-02  -0.55246D-01  -0.15546D-07  -0.18202D-03   0.14316D-04
Fuel Slosh Mass Locat.             600    -0.22168D-06   0.51049D-02   0.64349D-01  -0.70020D-07  -0.61504D-03   0.48847D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.46665D-04  -0.74626D-02  -0.94075D-01   0.21221D-03  -0.17886D-01   0.14190D-02

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    103.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.43586D-06   0.20870D-01   0.50396D-01   0.21113D-01   0.92629D-07   0.16076D-06
S1 Engine No:2 +Y-Z               1152    -0.83106D-07   0.50390D-01   0.20877D-01   0.21113D-01  -0.39119D-06  -0.38326D-06
S1 Engine No:3 -Y-Z               1153    -0.10568D-05   0.50390D-01  -0.20871D-01   0.21113D-01   0.68750D-06  -0.37496D-06
S1 Engine No:4 -Y-Z               1154    -0.12156D-05   0.20870D-01  -0.50391D-01   0.21113D-01   0.15965D-06   0.10635D-06
S1 Engine No:5 -Y+Z               1155    -0.11386D-05  -0.20877D-01  -0.50391D-01   0.21113D-01   0.14696D-06  -0.95303D-06
S1 Engine No:6 -Y+Z               1156    -0.23407D-06  -0.50397D-01  -0.20871D-01   0.21113D-01   0.61501D-06  -0.40530D-06
S1 Engine No:7 +Y+Z               1157     0.33944D-06  -0.50397D-01   0.20877D-01   0.21113D-01  -0.42132D-06  -0.41069D-06
S1 Engine No:8 +Y+Z               1158     0.88265D-06  -0.20877D-01   0.50396D-01   0.21113D-01   0.12622D-06  -0.89605D-06

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05  -0.26316D-01  -0.27137D-06   0.36439D-06
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05  -0.26316D-01  -0.27137D-06   0.36439D-06
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05  -0.26316D-01  -0.27137D-06   0.36439D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05
Stage-2 Tank Top, IMU Locat.     40015     0.27450D-06   0.20280D-05   0.29839D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10157D-06  -0.54081D-05   0.17104D-05  -0.41376D-02   0.22060D-07  -0.25321D-06
Fuel Slosh Mass Locat.             600    -0.11053D-06  -0.10503D-05  -0.14086D-05   0.14879D-01   0.91278D-07   0.41300D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.33261D-05   0.29211D-04  -0.10326D-04   0.24215D-01  -0.12518D-04  -0.26204D-04

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    110.84       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.41279D-05  -0.17748D-01  -0.42834D-01  -0.17948D-01   0.10843D-05   0.10763D-05
S1 Engine No:2 +Y-Z               1152    -0.35301D-05  -0.42843D-01  -0.17739D-01  -0.17948D-01   0.15458D-05   0.16134D-05
S1 Engine No:3 -Y-Z               1153    -0.12620D-06  -0.42843D-01   0.17750D-01  -0.17948D-01   0.48631D-06   0.16086D-05
S1 Engine No:4 -Y-Z               1154     0.33932D-05  -0.17748D-01   0.42845D-01  -0.17948D-01   0.10148D-05   0.11355D-05
S1 Engine No:5 -Y+Z               1155     0.56425D-05   0.17741D-01   0.42845D-01  -0.17948D-01   0.10340D-05   0.21700D-05
S1 Engine No:6 -Y+Z               1156     0.46658D-05   0.42836D-01   0.17750D-01  -0.17948D-01   0.56671D-06   0.16369D-05
S1 Engine No:7 +Y+Z               1157     0.16540D-05   0.42836D-01  -0.17739D-01  -0.17948D-01   0.15750D-05   0.16410D-05
S1 Engine No:8 +Y+Z               1158    -0.22425D-05   0.17741D-01  -0.42834D-01  -0.17948D-01   0.10487D-05   0.21107D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05   0.24637D-01  -0.11477D-05  -0.10331D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05   0.24637D-01  -0.11477D-05  -0.10331D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05   0.24637D-01  -0.11477D-05  -0.10331D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.73919D-06  -0.34008D-05   0.50683D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.20762D-06   0.90737D-05  -0.35238D-05   0.51185D-02   0.41953D-06   0.57892D-06
Fuel Slosh Mass Locat.             600     0.36648D-06   0.67058D-05  -0.52876D-05  -0.11889D-01  -0.29728D-06  -0.75047D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.48199D-05  -0.56174D-04   0.27636D-04  -0.21046D-01   0.20078D-04   0.41704D-04

MODE# 11/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    119.57       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.30881D-01  -0.70371D-01   0.54653D-02   0.43348D-04   0.87484D-03   0.11004D-01
S1 Engine No:2 +Y-Z               1152    -0.16646D-01  -0.70322D-01   0.54388D-02  -0.39142D-06   0.87984D-03   0.11092D-01
S1 Engine No:3 -Y-Z               1153     0.52834D-02  -0.70321D-01   0.54551D-02   0.53129D-05   0.87420D-03   0.11071D-01
S1 Engine No:4 -Y-Z               1154     0.21923D-01  -0.70370D-01   0.54230D-02   0.39523D-04   0.87322D-03   0.10957D-01
S1 Engine No:5 -Y+Z               1155     0.23637D-01  -0.70369D-01   0.54273D-02  -0.33653D-04   0.85715D-03   0.10961D-01
S1 Engine No:6 -Y+Z               1156     0.93955D-02  -0.70344D-01   0.54243D-02   0.19838D-04   0.83111D-03   0.11075D-01
S1 Engine No:7 +Y+Z               1157    -0.12538D-01  -0.70345D-01   0.54740D-02   0.97403D-05   0.83165D-03   0.11092D-01
S1 Engine No:8 +Y+Z               1158    -0.29177D-01  -0.70380D-01   0.54599D-02  -0.34040D-04   0.84833D-03   0.11004D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02  -0.14540D-04  -0.68678D-03  -0.89563D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02  -0.14540D-04  -0.68678D-03  -0.89563D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02  -0.14540D-04  -0.68678D-03  -0.89563D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02
Stage-2 Tank Top, IMU Locat.     40015     0.43495D-02  -0.16113D-01   0.12346D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.64135D-03   0.35430D-01  -0.27704D-02  -0.71146D-07   0.27610D-03   0.35744D-02
Fuel Slosh Mass Locat.             600    -0.26107D-02   0.53398D-01  -0.41428D-02   0.70331D-05  -0.20719D-03  -0.26393D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.14585D-02  -0.17375D+00   0.13655D-01  -0.37384D-02   0.66887D-02   0.84523D-01

MODE# 12/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    121.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.95002D-02   0.64831D-02   0.82532D-01   0.27884D-05   0.11869D-01  -0.92302D-03
S1 Engine No:2 +Y-Z               1152    -0.27329D-01   0.64615D-02   0.82574D-01  -0.37148D-04   0.11734D-01  -0.93463D-03
S1 Engine No:3 -Y-Z               1153    -0.29160D-01   0.64679D-02   0.82565D-01   0.43085D-04   0.11734D-01  -0.91436D-03
S1 Engine No:4 -Y-Z               1154    -0.13905D-01   0.64500D-02   0.82522D-01  -0.81238D-05   0.11869D-01  -0.90192D-03
S1 Engine No:5 -Y+Z               1155     0.95967D-02   0.64849D-02   0.82522D-01  -0.28381D-05   0.11872D-01  -0.92362D-03
S1 Engine No:6 -Y+Z               1156     0.27424D-01   0.64576D-02   0.82571D-01   0.46612D-04   0.11735D-01  -0.93037D-03
S1 Engine No:7 +Y+Z               1157     0.29251D-01   0.64627D-02   0.82574D-01  -0.42634D-04   0.11732D-01  -0.91592D-03
S1 Engine No:8 +Y+Z               1158     0.13999D-01   0.64459D-02   0.82532D-01   0.10839D-04   0.11870D-01  -0.90293D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01  -0.38952D-05  -0.10856D-01   0.86044D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01  -0.38952D-05  -0.10856D-01   0.86044D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01  -0.38952D-05  -0.10856D-01   0.86044D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.56912D-04   0.13629D-02   0.17180D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.29252D-05  -0.27447D-02  -0.35432D-01  -0.78805D-07   0.40054D-02  -0.31496D-03
Fuel Slosh Mass Locat.             600     0.38925D-04  -0.46112D-02  -0.59008D-01   0.17934D-05  -0.24536D-02   0.18871D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.21726D-03   0.11645D-01   0.15182D+00  -0.13140D-02   0.61559D-01  -0.46500D-02

MODE# 13/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    129.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.73567D-02  -0.74641D-03  -0.11531D-03  -0.13979D-05   0.21398D-03   0.26957D-02
S1 Engine No:2 +Y-Z               1152    -0.39399D-02  -0.74536D-03  -0.11443D-03  -0.33782D-06   0.22338D-03   0.26478D-02
S1 Engine No:3 -Y-Z               1153     0.12626D-02  -0.74489D-03  -0.11548D-03  -0.69220D-06   0.17023D-03   0.26380D-02
S1 Engine No:4 -Y-Z               1154     0.51982D-02  -0.74549D-03  -0.11477D-03  -0.15688D-05   0.16494D-03   0.26783D-02
S1 Engine No:5 -Y+Z               1155     0.55655D-02  -0.74323D-03  -0.11243D-03  -0.54268D-06   0.20842D-03   0.26828D-02
S1 Engine No:6 -Y+Z               1156     0.21481D-02  -0.74061D-03  -0.11336D-03  -0.54538D-06   0.20995D-03   0.26422D-02
S1 Engine No:7 +Y+Z               1157    -0.30548D-02  -0.74074D-03  -0.11678D-03  -0.74544D-06   0.15738D-03   0.26438D-02
S1 Engine No:8 +Y+Z               1158    -0.69903D-02  -0.74399D-03  -0.11813D-03  -0.62344D-06   0.15869D-03   0.26915D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03  -0.11998D-04   0.10148D-02   0.12671D-01
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03  -0.11998D-04   0.10148D-02   0.12671D-01
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03  -0.11998D-04   0.10148D-02   0.12671D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03
Stage-2 Tank Top, IMU Locat.     40015     0.12669D-02   0.83754D-02  -0.66974D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10194D-03   0.35951D-02  -0.22636D-03   0.20634D-05  -0.18379D-03  -0.22573D-02
Fuel Slosh Mass Locat.             600    -0.75106D-03   0.13279D-02   0.30263D-05   0.40673D-05  -0.11814D-03  -0.15446D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.53783D-02  -0.12048D+00   0.93525D-02  -0.45305D-02   0.68314D-02   0.86759D-01

MODE# 14/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.81       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.64579D-02  -0.38849D-02  -0.47179D-01   0.24889D-06  -0.81751D-02   0.65048D-03
S1 Engine No:2 +Y-Z               1152     0.18768D-01  -0.38672D-02  -0.47212D-01   0.26690D-04  -0.81090D-02   0.65782D-03
S1 Engine No:3 -Y-Z               1153     0.20084D-01  -0.38729D-02  -0.47209D-01  -0.26838D-04  -0.81109D-02   0.67220D-03
S1 Engine No:4 -Y-Z               1154     0.96234D-02  -0.38638D-02  -0.47182D-01   0.76565D-05  -0.81769D-02   0.66642D-03
S1 Engine No:5 -Y+Z               1155    -0.65521D-02  -0.38903D-02  -0.47182D-01   0.39298D-05  -0.81769D-02   0.65065D-03
S1 Engine No:6 -Y+Z               1156    -0.18861D-01  -0.38743D-02  -0.47214D-01  -0.29384D-04  -0.81094D-02   0.65460D-03
S1 Engine No:7 +Y+Z               1157    -0.20174D-01  -0.38791D-02  -0.47212D-01   0.30672D-04  -0.81101D-02   0.67344D-03
S1 Engine No:8 +Y+Z               1158    -0.97160D-02  -0.38649D-02  -0.47180D-01  -0.54468D-05  -0.81775D-02   0.66743D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02   0.36978D-05  -0.11583D-01   0.90797D-03
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02   0.36978D-05  -0.11583D-01   0.90797D-03
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02   0.36978D-05  -0.11583D-01   0.90797D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02
Stage-2 Tank Top, IMU Locat.     40015     0.69231D-04   0.38066D-03   0.48454D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.44020D-05   0.11093D-02   0.13491D-01  -0.86293D-06   0.13499D-02  -0.10312D-03
Fuel Slosh Mass Locat.             600    -0.40636D-04   0.23158D-02   0.28204D-01  -0.10304D-05   0.23420D-02  -0.18821D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.34781D-03  -0.11274D-01  -0.14116D+00   0.18592D-02  -0.74897D-01   0.59287D-02

MODE# 15/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    142.33       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.30942D-01   0.11540D+00  -0.94226D-02  -0.11325D-03  -0.96806D-03  -0.12289D-01
S1 Engine No:2 +Y-Z               1152     0.14765D-01   0.11528D+00  -0.93497D-02  -0.24642D-05  -0.93324D-03  -0.12650D-01
S1 Engine No:3 -Y-Z               1153    -0.10363D-01   0.11528D+00  -0.93863D-02  -0.18193D-04  -0.10571D-02  -0.12661D-01
S1 Engine No:4 -Y-Z               1154    -0.29401D-01   0.11540D+00  -0.93016D-02  -0.10344D-03  -0.10917D-02  -0.12301D-01
S1 Engine No:5 -Y+Z               1155    -0.31457D-01   0.11541D+00  -0.93064D-02   0.76622D-04  -0.97517D-03  -0.12299D-01
S1 Engine No:6 -Y+Z               1156    -0.15267D-01   0.11536D+00  -0.93072D-02  -0.54025D-04  -0.93013D-03  -0.12659D-01
S1 Engine No:7 +Y+Z               1157     0.98701D-02   0.11536D+00  -0.94462D-02  -0.30428D-04  -0.10673D-02  -0.12661D-01
S1 Engine No:8 +Y+Z               1158     0.28908D-01   0.11543D+00  -0.94196D-02   0.77917D-04  -0.10827D-02  -0.12300D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03  -0.20816D-04  -0.28420D-03  -0.34730D-02
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03  -0.20816D-04  -0.28420D-03  -0.34730D-02
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03  -0.20816D-04  -0.28420D-03  -0.34730D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03
Stage-2 Tank Top, IMU Locat.     40015     0.73196D-03   0.18979D-02  -0.15547D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.14553D-03  -0.16754D-01   0.13592D-02   0.84942D-05  -0.63793D-04  -0.78979D-03
Fuel Slosh Mass Locat.             600    -0.46750D-03  -0.62292D-01   0.50579D-02  -0.13105D-05   0.12482D-03   0.15362D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.94485D-02  -0.58543D-01   0.47370D-02  -0.70517D-02   0.87227D-02   0.10763D+00

MODE# 16/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    150.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.70918D-02   0.76658D-02   0.93809D-01   0.44857D-04   0.88584D-02  -0.78120D-03
S1 Engine No:2 +Y-Z               1152    -0.20454D-01   0.77090D-02   0.93791D-01   0.61823D-05   0.85284D-02  -0.81208D-03
S1 Engine No:3 -Y-Z               1153    -0.21885D-01   0.77213D-02   0.93680D-01   0.10043D-03   0.85152D-02  -0.62557D-03
S1 Engine No:4 -Y-Z               1154    -0.10525D-01   0.76307D-02   0.93558D-01   0.47357D-04   0.88448D-02  -0.59828D-03
S1 Engine No:5 -Y+Z               1155     0.70910D-02   0.75716D-02   0.93557D-01   0.52609D-04   0.88622D-02  -0.78336D-03
S1 Engine No:6 -Y+Z               1156     0.20451D-01   0.74680D-02   0.93689D-01   0.10876D-03   0.85273D-02  -0.80502D-03
S1 Engine No:7 +Y+Z               1157     0.21876D-01   0.74779D-02   0.93793D-01  -0.22096D-05   0.85116D-02  -0.62808D-03
S1 Engine No:8 +Y+Z               1158     0.10521D-01   0.75265D-02   0.93809D-01   0.56280D-04   0.88460D-02  -0.59879D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02   0.28793D-04   0.13432D-02  -0.10845D-03
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02   0.28793D-04   0.13432D-02  -0.10845D-03
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02   0.28793D-04   0.13432D-02  -0.10845D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02
Stage-2 Tank Top, IMU Locat.     40015     0.82167D-04   0.14215D-03   0.17610D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.25861D-04  -0.76807D-03  -0.94726D-02  -0.16451D-04   0.81640D-03  -0.66226D-04
Fuel Slosh Mass Locat.             600    -0.45985D-04  -0.40421D-02  -0.49865D-01   0.13780D-04  -0.53044D-03   0.42984D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.12160D-02  -0.13381D-01  -0.16465D+00   0.56905D-02  -0.17102D+00   0.13910D-01

MODE# 17/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    156.58       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.30985D-04  -0.35088D-01  -0.84344D-01  -0.35402D-01   0.14022D-04   0.45636D-05
S1 Engine No:2 +Y-Z               1152    -0.41101D-04  -0.84590D-01  -0.34843D-01  -0.35402D-01   0.15197D-04   0.71388D-05
S1 Engine No:3 -Y-Z               1153    -0.25669D-04  -0.84590D-01   0.35165D-01  -0.35402D-01   0.11183D-04   0.74321D-05
S1 Engine No:4 -Y-Z               1154     0.31384D-05  -0.35088D-01   0.84666D-01  -0.35402D-01   0.13980D-04   0.51199D-05
S1 Engine No:5 -Y+Z               1155     0.31766D-04   0.34919D-01   0.84666D-01  -0.35402D-01   0.13829D-04   0.89179D-05
S1 Engine No:6 -Y+Z               1156     0.40302D-04   0.84421D-01   0.35164D-01  -0.35402D-01   0.11237D-04   0.72169D-05
S1 Engine No:7 +Y+Z               1157     0.26471D-04   0.84421D-01  -0.34842D-01  -0.35402D-01   0.15516D-04   0.75607D-05
S1 Engine No:8 +Y+Z               1158    -0.38858D-05   0.34919D-01  -0.84344D-01  -0.35402D-01   0.14078D-04   0.90576D-05

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05  -0.14730D-01   0.15917D-05   0.83011D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05  -0.14730D-01   0.15917D-05   0.83011D-06
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05  -0.14730D-01   0.15917D-05   0.83011D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.47654D-06  -0.15302D-05   0.29412D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.19486D-06   0.66683D-05  -0.12675D-04   0.10061D-01   0.15002D-05   0.78836D-06
Fuel Slosh Mass Locat.             600     0.23184D-06   0.45333D-04  -0.86259D-04  -0.12209D-01  -0.28480D-06  -0.15686D-06

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.76199D-05   0.19447D-03  -0.38299D-03  -0.50320D-01  -0.34885D-03  -0.17183D-03

MODE# 18/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    205.68       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.11551D-01  -0.34900D-01   0.22499D-02   0.61446D-04   0.30191D-03   0.46385D-02
S1 Engine No:2 +Y-Z               1152    -0.53047D-02  -0.34839D-01   0.22202D-02  -0.14972D-04   0.28723D-03   0.48362D-02
S1 Engine No:3 -Y-Z               1153     0.43048D-02  -0.34839D-01   0.22785D-02  -0.59234D-05   0.30311D-03   0.48404D-02
S1 Engine No:4 -Y-Z               1154     0.11416D-01  -0.34901D-01   0.22429D-02   0.53866D-04   0.32554D-03   0.46471D-02
S1 Engine No:5 -Y+Z               1155     0.12050D-01  -0.34875D-01   0.22470D-02  -0.69896D-04   0.31019D-03   0.46522D-02
S1 Engine No:6 -Y+Z               1156     0.57947D-02  -0.34817D-01   0.22233D-02   0.22555D-04   0.29062D-03   0.48451D-02
S1 Engine No:7 +Y+Z               1157    -0.38232D-02  -0.34817D-01   0.22897D-02   0.72832D-05   0.31612D-03   0.48383D-02
S1 Engine No:8 +Y+Z               1158    -0.10934D-01  -0.34889D-01   0.22474D-02  -0.71292D-04   0.32066D-03   0.46398D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03  -0.23882D-06   0.80590D-04   0.12637D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03  -0.23882D-06   0.80590D-04   0.12637D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03  -0.23882D-06   0.80590D-04   0.12637D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.92597D-04  -0.94469D-02   0.60139D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.10099D-03   0.81455D-01  -0.52643D-02   0.41693D-06  -0.11744D-03  -0.18023D-02
Fuel Slosh Mass Locat.             600     0.97909D-04  -0.19971D-01   0.12994D-02  -0.16399D-05  -0.28753D-03  -0.44389D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.88532D-03  -0.19997D-01   0.13940D-02   0.97991D-03  -0.21138D-03  -0.44134D-02

MODE# 19/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    247.37       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.93223D-02  -0.20592D-01   0.47641D-04   0.58147D-04   0.42534D-04   0.36828D-02
S1 Engine No:2 +Y-Z               1152    -0.41463D-02  -0.20529D-01   0.13510D-04  -0.10785D-04   0.51668D-04   0.37964D-02
S1 Engine No:3 -Y-Z               1153     0.33554D-02  -0.20529D-01   0.66192D-04  -0.89287D-05  -0.16276D-04   0.37856D-02
S1 Engine No:4 -Y-Z               1154     0.85567D-02  -0.20588D-01   0.33201D-04   0.51352D-04  -0.95080D-05   0.36604D-02
S1 Engine No:5 -Y+Z               1155     0.85880D-02  -0.20567D-01   0.37777D-04  -0.64913D-04   0.38291D-04   0.36678D-02
S1 Engine No:6 -Y+Z               1156     0.34014D-02  -0.20510D-01   0.12848D-04   0.21665D-04   0.25756D-04   0.37930D-02
S1 Engine No:7 +Y+Z               1157    -0.41101D-02  -0.20512D-01   0.80025D-04   0.13123D-04  -0.32550D-04   0.37972D-02
S1 Engine No:8 +Y+Z               1158    -0.93102D-02  -0.20579D-01   0.43566D-04  -0.67774D-04  -0.28388D-04   0.36821D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03  -0.91094D-07  -0.39367D-05  -0.19432D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03  -0.91094D-07  -0.39367D-05  -0.19432D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03  -0.91094D-07  -0.39367D-05  -0.19432D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.84488D-02   0.63577D-01  -0.12926D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.19049D-03  -0.84372D-01   0.18001D-03   0.24353D-06  -0.16950D-04  -0.82878D-02
Fuel Slosh Mass Locat.             600     0.99431D-04  -0.23789D-01   0.59010D-04  -0.15221D-05  -0.44298D-05  -0.20124D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.12528D-02  -0.12773D-01   0.24846D-03   0.10355D-02   0.15486D-03  -0.68654D-03

MODE# 20/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    247.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.39325D-02  -0.62305D-04  -0.21597D-01  -0.90637D-05  -0.39893D-02  -0.25013D-04
S1 Engine No:2 +Y-Z               1152     0.94135D-02  -0.32208D-04  -0.21655D-01   0.53765D-04  -0.38717D-02  -0.18378D-04
S1 Engine No:3 -Y-Z               1153     0.94292D-02  -0.39168D-04  -0.21651D-01  -0.55814D-04  -0.38724D-02   0.33210D-04
S1 Engine No:4 -Y-Z               1154     0.39644D-02  -0.12980D-04  -0.21595D-01   0.14532D-04  -0.39910D-02   0.35885D-04
S1 Engine No:5 -Y+Z               1155    -0.39358D-02  -0.75236D-04  -0.21595D-01   0.15848D-04  -0.39929D-02  -0.24125D-04
S1 Engine No:6 -Y+Z               1156    -0.94128D-02  -0.44040D-04  -0.21657D-01  -0.63332D-04  -0.38701D-02  -0.25446D-04
S1 Engine No:7 +Y+Z               1157    -0.94209D-02  -0.49023D-04  -0.21662D-01   0.60818D-04  -0.38692D-02   0.34517D-04
S1 Engine No:8 +Y+Z               1158    -0.39619D-02  -0.13552D-04  -0.21597D-01  -0.92753D-05  -0.39899D-02   0.36660D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01   0.44041D-06   0.19758D-02  -0.37998D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01   0.44041D-06   0.19758D-02  -0.37998D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01   0.44041D-06   0.19758D-02  -0.37998D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.15386D-04   0.12665D-03   0.66116D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.94579D-06  -0.16101D-03  -0.88772D-01  -0.22685D-06   0.86598D-02  -0.16480D-04
Fuel Slosh Mass Locat.             600     0.11673D-05  -0.36600D-04  -0.25016D-01   0.13381D-05   0.21049D-02  -0.36674D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.20996D-04   0.21671D-03  -0.10407D-01  -0.89908D-03   0.28375D-02  -0.17244D-03

MODE# 21/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    280.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.26688D-03  -0.93916D-03  -0.35470D-03  -0.34480D-03   0.76075D-04   0.89082D-04
S1 Engine No:2 +Y-Z               1152    -0.24026D-03  -0.14238D-02   0.13172D-03  -0.34981D-03   0.70931D-04   0.95750D-04
S1 Engine No:3 -Y-Z               1153    -0.49683D-04  -0.14237D-02   0.82151D-03  -0.34622D-03   0.69245D-04   0.96168D-04
S1 Engine No:4 -Y-Z               1154     0.18363D-03  -0.94081D-03   0.13046D-02  -0.34596D-03   0.75215D-04   0.90538D-04
S1 Engine No:5 -Y+Z               1155     0.33544D-03  -0.25022D-03   0.13047D-02  -0.35087D-03   0.77443D-04   0.91782D-04
S1 Engine No:6 -Y+Z               1156     0.30817D-03   0.23720D-03   0.81942D-03  -0.34460D-03   0.72858D-04   0.97284D-04
S1 Engine No:7 +Y+Z               1157     0.11695D-03   0.23724D-03   0.13506D-03  -0.34890D-03   0.71773D-04   0.95215D-04
S1 Engine No:8 +Y+Z               1158    -0.11615D-03  -0.25276D-03  -0.35465D-03  -0.35015D-03   0.75782D-04   0.88351D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04  -0.59743D-04   0.12203D-06   0.23099D-06
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04  -0.59743D-04   0.12203D-06   0.23099D-06
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04  -0.59743D-04   0.12203D-06   0.23099D-06

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04
Stage-2 Tank Top, IMU Locat.     40015     0.79478D-05  -0.94050D-04   0.78605D-04

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.14285D-04  -0.24937D-03   0.18963D-03   0.20920D-03   0.41213D-05   0.42894D-05
Fuel Slosh Mass Locat.             600     0.28396D-04  -0.37058D-03   0.29283D-03  -0.17011D-02  -0.19108D-04  -0.23557D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.63137D-03  -0.72091D-02   0.52875D-02   0.11759D+01   0.22507D-02   0.35880D-02

MODE# 22/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    297.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.16023D-01   0.44146D-01  -0.29296D-03  -0.22250D-03  -0.83616D-04  -0.62983D-02
S1 Engine No:2 +Y-Z               1152     0.68622D-02   0.43920D-01  -0.15730D-03   0.43336D-04  -0.92789D-04  -0.68612D-02
S1 Engine No:3 -Y-Z               1153    -0.67825D-02   0.43921D-01  -0.36572D-03   0.35220D-04   0.31906D-04  -0.68570D-02
S1 Engine No:4 -Y-Z               1154    -0.16056D-01   0.44134D-01  -0.23648D-03  -0.19470D-03  -0.19351D-04  -0.62946D-02
S1 Engine No:5 -Y+Z               1155    -0.16190D-01   0.44057D-01  -0.23605D-03   0.24274D-03  -0.10575D-03  -0.63226D-02
S1 Engine No:6 -Y+Z               1156    -0.69895D-02   0.43864D-01  -0.14776D-03  -0.96546D-04  -0.76516D-04  -0.68890D-02
S1 Engine No:7 +Y+Z               1157     0.67011D-02   0.43868D-01  -0.43624D-03  -0.60383D-04   0.17278D-04  -0.68677D-02
S1 Engine No:8 +Y+Z               1158     0.15965D-01   0.44105D-01  -0.29877D-03   0.25404D-03   0.19085D-04  -0.62945D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03  -0.14216D-06   0.23135D-06  -0.23610D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03  -0.14216D-06   0.23135D-06  -0.23610D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03  -0.14216D-06   0.23135D-06  -0.23610D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.59702D-03   0.23177D-01  -0.12846D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.76113D-04   0.11273D+00  -0.57520D-03   0.55714D-06   0.45138D-05   0.11292D-02
Fuel Slosh Mass Locat.             600    -0.97258D-04   0.62587D-01  -0.33330D-03  -0.50468D-05   0.16902D-04   0.30323D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.20078D-02   0.30287D-01  -0.53481D-03   0.34663D-02  -0.24695D-03  -0.40771D-03

MODE# 23/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    297.77       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.66800D-02   0.27043D-03   0.43307D-01   0.42583D-04   0.67907D-02   0.16162D-04
S1 Engine No:2 +Y-Z               1152    -0.15891D-01   0.16781D-03   0.43493D-01  -0.18626D-03   0.62666D-02  -0.69966D-05
S1 Engine No:3 -Y-Z               1153    -0.15964D-01   0.17314D-03   0.43471D-01   0.20123D-03   0.62693D-02  -0.64078D-04
S1 Engine No:4 -Y-Z               1154    -0.68341D-02   0.76786D-04   0.43285D-01  -0.58450D-04   0.67988D-02  -0.70770D-04
S1 Engine No:5 -Y+Z               1155     0.66975D-02   0.31414D-03   0.43285D-01  -0.58822D-04   0.68029D-02   0.15203D-04
S1 Engine No:6 -Y+Z               1156     0.15891D-01   0.19682D-03   0.43496D-01   0.22678D-03   0.62604D-02   0.18682D-04
S1 Engine No:7 +Y+Z               1157     0.15936D-01   0.19545D-03   0.43519D-01  -0.21077D-03   0.62575D-02  -0.66899D-04
S1 Engine No:8 +Y+Z               1158     0.68281D-02   0.72448D-04   0.43307D-01   0.41300D-04   0.67918D-02  -0.74603D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01   0.36689D-06  -0.43573D-04  -0.19265D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01   0.36689D-06  -0.43573D-04  -0.19265D-07
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01   0.36689D-06  -0.43573D-04  -0.19265D-07

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.33860D-05   0.12035D-03   0.24505D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.12665D-05   0.59203D-03   0.11097D+00  -0.48958D-06  -0.92173D-03   0.61895D-05
Fuel Slosh Mass Locat.             600    -0.23031D-05   0.31984D-03   0.62589D-01   0.38386D-05  -0.29948D-02   0.14518D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.51669D-04  -0.24871D-03   0.24776D-01  -0.26644D-02  -0.30948D-02   0.26149D-03

MODE# 24/ 39, Frequency (rad/sec), Damping (zeta), Generalized Mass=    374.18       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.15123D-01  -0.28717D-01   0.71421D-04   0.40798D-03   0.34786D-03   0.62288D-02
S1 Engine No:2 +Y-Z               1152    -0.65504D-02  -0.28283D-01  -0.22868D-03  -0.74707D-04   0.41711D-03   0.68042D-02
S1 Engine No:3 -Y-Z               1153     0.68069D-02  -0.28283D-01   0.14989D-03  -0.79584D-04  -0.43408D-03   0.68041D-02
S1 Engine No:4 -Y-Z               1154     0.15438D-01  -0.28646D-01  -0.93482D-04   0.32176D-03  -0.27422D-03   0.62375D-02
S1 Engine No:5 -Y+Z               1155     0.15613D-01  -0.28419D-01  -0.11908D-03  -0.48365D-03   0.43019D-03   0.63049D-02
S1 Engine No:6 -Y+Z               1156     0.69192D-02  -0.28081D-01  -0.27324D-03   0.26996D-03   0.38923D-03   0.69284D-02
S1 Engine No:7 +Y+Z               1157    -0.66420D-02  -0.28094D-01   0.42006D-03   0.16088D-03  -0.42487D-03   0.68572D-02
S1 Engine No:8 +Y+Z               1158    -0.15197D-01  -0.28572D-01   0.11474D-03  -0.52774D-03  -0.40363D-03   0.62095D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05   0.10418D-07  -0.10509D-05  -0.46667D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05   0.10418D-07  -0.10509D-05  -0.46667D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05   0.10418D-07  -0.10509D-05  -0.46667D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05
Stage-2 Tank Top, IMU Locat.     40015    -0.72186D-03  -0.44599D-01   0.89535D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.26045D-03   0.59487D-01  -0.20864D-04  -0.43292D-07   0.23513D-05   0.89288D-02
Fuel Slosh Mass Locat.             600    -0.90711D-05  -0.39811D-01   0.33666D-04   0.59892D-06   0.12245D-05  -0.30988D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.24567D-02  -0.19110D-01   0.26452D-03  -0.37093D-03   0.18401D-03   0.34273D-02

MODE# 25/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    376.70       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.74670D-02  -0.17988D-03  -0.32013D-01  -0.13628D-03  -0.76286D-02  -0.43055D-03
S1 Engine No:2 +Y-Z               1152     0.17185D-01   0.37045D-04  -0.32377D-01   0.38028D-03  -0.70135D-02  -0.33756D-03
S1 Engine No:3 -Y-Z               1153     0.17236D-01   0.55869D-04  -0.32289D-01  -0.44838D-03  -0.70163D-02   0.37878D-03
S1 Engine No:4 -Y-Z               1154     0.75084D-02   0.25870D-03  -0.31914D-01   0.20303D-03  -0.76724D-02   0.42308D-03
S1 Engine No:5 -Y+Z               1155    -0.75746D-02  -0.38187D-03  -0.31919D-01   0.17027D-03  -0.76649D-02  -0.45418D-03
S1 Engine No:6 -Y+Z               1156    -0.17198D-01  -0.81239D-04  -0.32401D-01  -0.53252D-03  -0.69836D-02  -0.43396D-03
S1 Engine No:7 +Y+Z               1157    -0.17124D-01  -0.41188D-04  -0.32496D-01   0.45917D-03  -0.69712D-02   0.36920D-03
S1 Engine No:8 +Y+Z               1158    -0.75008D-02   0.28317D-03  -0.32019D-01  -0.89236D-04  -0.76091D-02   0.44960D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01   0.90382D-06   0.46688D-02  -0.14819D-05
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01   0.90382D-06   0.46688D-02  -0.14819D-05
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01   0.90382D-06   0.46688D-02  -0.14819D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01
Stage-2 Tank Top, IMU Locat.     40015     0.21480D-06  -0.15016D-04  -0.42827D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.18222D-05   0.10076D-04   0.62268D-01  -0.31256D-06  -0.89356D-02   0.23831D-05
Fuel Slosh Mass Locat.             600     0.29051D-05   0.17934D-04  -0.42622D-01  -0.45812D-06   0.19500D-03  -0.16086D-05

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.55314D-04   0.29316D-03  -0.17387D-01   0.31478D-03  -0.93569D-03  -0.20863D-03

MODE# 26/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    393.85       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.83988D-01   0.15500D+00  -0.54367D-02  -0.31538D-02  -0.37298D-02  -0.33286D-01
S1 Engine No:2 +Y-Z               1152     0.40151D-01   0.15144D+00  -0.27556D-02   0.27486D-03  -0.44357D-02  -0.37678D-01
S1 Engine No:3 -Y-Z               1153    -0.33483D-01   0.15140D+00  -0.51615D-02   0.45941D-03   0.22150D-02  -0.37571D-01
S1 Engine No:4 -Y-Z               1154    -0.81041D-01   0.15390D+00  -0.33593D-02  -0.20344D-02   0.62539D-03  -0.33125D-01
S1 Engine No:5 -Y+Z               1155    -0.85166D-01   0.15119D+00  -0.30644D-02   0.40462D-02  -0.45926D-02  -0.33888D-01
S1 Engine No:6 -Y+Z               1156    -0.39791D-01   0.14888D+00  -0.22582D-02  -0.28453D-02  -0.38484D-02  -0.39241D-01
S1 Engine No:7 +Y+Z               1157     0.36588D-01   0.14905D+00  -0.87795D-02  -0.13842D-02   0.26639D-02  -0.38420D-01
S1 Engine No:8 +Y+Z               1158     0.82900D-01   0.15323D+00  -0.59531D-02   0.46666D-02   0.23990D-02  -0.32936D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03  -0.49817D-07  -0.45012D-04  -0.13232D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03  -0.49817D-07  -0.45012D-04  -0.13232D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03  -0.49817D-07  -0.45012D-04  -0.13232D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.35864D-03  -0.17690D-01   0.57375D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.11500D-02  -0.34223D-01   0.98256D-03   0.19266D-06  -0.81871D-05  -0.53525D-03
Fuel Slosh Mass Locat.             600    -0.13441D-02   0.13763D+00  -0.41942D-02  -0.27566D-05  -0.14899D-03  -0.48254D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.19664D-01   0.10324D+00  -0.38774D-02   0.16399D-02  -0.11888D-02  -0.22160D-01

MODE# 27/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    394.32       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151    -0.34074D-01   0.56894D-02   0.15253D+00   0.91759D-03   0.37735D-01   0.17680D-02
S1 Engine No:2 +Y-Z               1152    -0.82199D-01   0.43066D-02   0.15475D+00  -0.23160D-02   0.33588D-01   0.91548D-03
S1 Engine No:3 -Y-Z               1153    -0.85086D-01   0.40964D-02   0.15376D+00   0.30739D-02   0.33827D-01  -0.37642D-02
S1 Engine No:4 -Y-Z               1154    -0.39782D-01   0.30377D-02   0.15155D+00  -0.17999D-02   0.38376D-01  -0.38407D-02
S1 Engine No:5 -Y+Z               1155     0.35254D-01   0.78041D-02   0.15163D+00  -0.10754D-02   0.38005D-01   0.21095D-02
S1 Engine No:6 -Y+Z               1156     0.82294D-01   0.54318D-02   0.15514D+00   0.38070D-02   0.33254D-01   0.18450D-02
S1 Engine No:7 +Y+Z               1157     0.83972D-01   0.50170D-02   0.15591D+00  -0.31674D-02   0.33359D-01  -0.36458D-02
S1 Engine No:8 +Y+Z               1158     0.39817D-01   0.26432D-02   0.15260D+00   0.52870D-03   0.37642D-01  -0.41700D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01   0.21596D-06   0.14441D-02  -0.39974D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01   0.21596D-06   0.14441D-02  -0.39974D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01   0.21596D-06   0.14441D-02  -0.39974D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.14934D-04  -0.53740D-03  -0.18524D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.54144D-04  -0.10631D-02  -0.32642D-01  -0.22158D-06   0.34259D-03  -0.18326D-04
Fuel Slosh Mass Locat.             600    -0.64189D-04   0.42127D-02   0.13682D+00   0.18113D-05   0.47904D-02  -0.14564D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.93893D-03   0.17936D-02   0.82105D-01  -0.11725D-02   0.68821D-02   0.30714D-03

MODE# 28/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    436.90       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.14080D-01   0.39006D-01   0.34313D-02  -0.23153D-01  -0.17656D-01   0.70799D-02
S1 Engine No:2 +Y-Z               1152     0.23630D-01   0.21992D-01   0.14696D-01   0.11754D-01  -0.17047D-01  -0.27203D-01
S1 Engine No:3 -Y-Z               1153    -0.25597D-01   0.22554D-01  -0.17480D-01   0.68430D-02   0.20832D-01  -0.23813D-01
S1 Engine No:4 -Y-Z               1154    -0.10949D-01   0.42708D-01  -0.19782D-02  -0.21289D-01   0.13871D-01   0.11157D-01
S1 Engine No:5 -Y+Z               1155    -0.14381D-01   0.39650D-01   0.29601D-02   0.22922D-01  -0.17482D-01   0.70854D-02
S1 Engine No:6 -Y+Z               1156    -0.24108D-01   0.22508D-01   0.14481D-01  -0.11261D-01  -0.17113D-01  -0.26869D-01
S1 Engine No:7 +Y+Z               1157     0.24466D-01   0.23033D-01  -0.16783D-01  -0.66233D-02   0.20610D-01  -0.23557D-01
S1 Engine No:8 +Y+Z               1158     0.10091D-01   0.42864D-01  -0.14785D-02   0.20813D-01   0.13532D-01   0.11122D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03  -0.59761D-08   0.30432D-04   0.34518D-02
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03  -0.59761D-08   0.30432D-04   0.34518D-02
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03  -0.59761D-08   0.30432D-04   0.34518D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03
Stage-2 Tank Top, IMU Locat.     40015     0.16193D-03   0.47239D-01  -0.41367D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601    -0.57611D-03   0.16526D+00  -0.14409D-02   0.27889D-07   0.11662D-03   0.13387D-01
Fuel Slosh Mass Locat.             600     0.14910D-03  -0.10299D-01   0.93614D-04  -0.44405D-06  -0.29789D-04  -0.34236D-02

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.63058D-02   0.21391D-01  -0.44089D-03   0.23555D-03  -0.23279D-03  -0.65040D-02

MODE# 29/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    436.94       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.21985D-01  -0.13945D-01  -0.24459D-01  -0.77792D-02  -0.22895D-01  -0.16037D-01
S1 Engine No:2 +Y-Z               1152     0.13554D-01  -0.25064D-02  -0.40303D-01   0.18857D-01   0.64321D-02  -0.13326D-01
S1 Engine No:3 -Y-Z               1153     0.13528D-01   0.16682D-02  -0.40530D-01  -0.18676D-01   0.64900D-02   0.13312D-01
S1 Engine No:4 -Y-Z               1154     0.22225D-01   0.13183D-01  -0.24680D-01   0.75565D-02  -0.22728D-01   0.16226D-01
S1 Engine No:5 -Y+Z               1155    -0.21744D-01  -0.13562D-01  -0.24651D-01   0.77783D-02  -0.22856D-01  -0.15936D-01
S1 Engine No:6 -Y+Z               1156    -0.13508D-01  -0.22979D-02  -0.40281D-01  -0.18635D-01   0.63792D-02  -0.13190D-01
S1 Engine No:7 +Y+Z               1157    -0.13724D-01   0.18590D-02  -0.40159D-01   0.18757D-01   0.64344D-02   0.13398D-01
S1 Engine No:8 +Y+Z               1158    -0.22244D-01   0.13165D-01  -0.24450D-01  -0.78508D-02  -0.22926D-01   0.16165D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01   0.43321D-07   0.34852D-02  -0.30475D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01   0.43321D-07   0.34852D-02  -0.30475D-04
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01   0.43321D-07   0.34852D-02  -0.30475D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01
Stage-2 Tank Top, IMU Locat.     40015    -0.32936D-05  -0.41672D-03  -0.47334D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.14620D-04  -0.14579D-02  -0.16487D+00  -0.21581D-07   0.13355D-01  -0.11819D-03
Fuel Slosh Mass Locat.             600    -0.44297D-05   0.84644D-04   0.99971D-02  -0.28225D-06  -0.34202D-02   0.30289D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159    -0.14385D-03   0.11458D-03  -0.16121D-01   0.16868D-03  -0.26928D-02  -0.15598D-03

MODE# 30/ 67, Frequency (rad/sec), Damping (zeta), Generalized Mass=    589.84       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.78876D-01   0.45701D-01   0.97462D-02   0.11910D-02   0.39337D-02  -0.47983D-01
S1 Engine No:2 +Y-Z               1152     0.16052D-01   0.46230D-01   0.90735D-02  -0.18390D-03   0.51721D-02  -0.37748D-01
S1 Engine No:3 -Y-Z               1153    -0.55504D-01   0.46479D-01   0.10856D-01  -0.83947D-03   0.16966D-01  -0.40022D-01
S1 Engine No:4 -Y-Z               1154    -0.95516D-01   0.46293D-01   0.10496D-01   0.14785D-02   0.13439D-01  -0.50927D-01
S1 Engine No:5 -Y+Z               1155    -0.79560D-01   0.45991D-01   0.93752D-02  -0.18540D-02   0.41116D-02  -0.49036D-01
S1 Engine No:6 -Y+Z               1156    -0.16002D-01   0.47093D-01   0.83771D-02   0.10275D-02   0.60510D-02  -0.36587D-01
S1 Engine No:7 +Y+Z               1157     0.53629D-01   0.47242D-01   0.12088D-01   0.84428D-03   0.15275D-01  -0.39316D-01
S1 Engine No:8 +Y+Z               1158     0.94952D-01   0.46094D-01   0.10819D-01  -0.17718D-02   0.13553D-01  -0.51788D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02  -0.19320D-07   0.17915D-03  -0.80506D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02  -0.19320D-07   0.17915D-03  -0.80506D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02  -0.19320D-07   0.17915D-03  -0.80506D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.29588D-04   0.62305D-02   0.13873D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.10419D-03  -0.82528D-02  -0.18371D-02   0.54634D-08  -0.37120D-03   0.16674D-02
Fuel Slosh Mass Locat.             600     0.22948D-03  -0.13347D+00  -0.29713D-01   0.10786D-05  -0.60282D-04   0.27182D-03

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.17937D-01  -0.95227D-01  -0.16830D-01  -0.10981D-03  -0.23026D-02   0.23076D-01

MODE# 31/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    590.09       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
S1 Engine No:1 +Y-Z               1151     0.55288D-01   0.11369D-01  -0.46981D-01   0.12190D-02  -0.39710D-01  -0.16964D-01
S1 Engine No:2 +Y-Z               1152     0.95312D-01   0.11014D-01  -0.46732D-01  -0.15818D-02  -0.51041D-01  -0.13433D-01
S1 Engine No:3 -Y-Z               1153     0.79248D-01   0.99007D-02  -0.46469D-01   0.16050D-02  -0.48638D-01  -0.40432D-02
S1 Engine No:4 -Y-Z               1154     0.16032D-01   0.92737D-02  -0.47154D-01  -0.85685D-03  -0.37303D-01  -0.53665D-02
S1 Engine No:5 -Y+Z               1155    -0.54979D-01   0.12041D-01  -0.47304D-01  -0.73858D-03  -0.40038D-01  -0.16544D-01
S1 Engine No:6 -Y+Z               1156    -0.95326D-01   0.11393D-01  -0.46850D-01   0.14910D-02  -0.50927D-01  -0.13508D-01
S1 Engine No:7 +Y+Z               1157    -0.79938D-01   0.10385D-01  -0.45818D-01  -0.78650D-03  -0.48766D-01  -0.32188D-02
S1 Engine No:8 +Y+Z               1158    -0.16308D-01   0.92833D-02  -0.46645D-01  -0.30954D-03  -0.38261D-01  -0.57283D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02   0.12202D-07  -0.80760D-03  -0.17898D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02   0.12202D-07  -0.80760D-03  -0.17898D-03
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02   0.12202D-07  -0.80760D-03  -0.17898D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02
Stage-2 Tank Top, IMU Locat.     40015    -0.64550D-05   0.13850D-02  -0.62534D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX  Slosh Mass Locat.             601     0.22656D-04  -0.18446D-02   0.83262D-02  -0.34108D-07   0.16697D-02   0.36988D-03
Fuel Slosh Mass Locat.             600     0.49824D-04  -0.29665D-01   0.13391D+00   0.11870D-06   0.26196D-03   0.58230D-04

                              Node ID#     Modal Data at the Disturbance Point 
S1 Engine No:9 center             1159     0.39692D-02  -0.22805D-01   0.83450D-01  -0.19790D-03   0.15712D-01   0.62786D-02
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
